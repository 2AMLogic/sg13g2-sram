v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {gates/inv.sym} 0 0 0 0 {name=XEB}
C {devices/lab_pin.sym} -40.0 -30.0 0 0 {name=l0 lab=SAE}
C {devices/lab_pin.sym} -40.0 -10.0 0 0 {name=l1 lab=SAEB}
C {devices/lab_pin.sym} -40.0 10.0 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} -40.0 30.0 0 0 {name=l3 lab=VSS}
C {latches/dlatch.sym} 400 0 0 0 {name=XL[31:0]}
C {devices/lab_pin.sym} 360.0 -50.0 0 0 {name=l4 lab=D[31:0]}
C {devices/lab_pin.sym} 360.0 -30.0 0 0 {name=l5 lab=SAE}
C {devices/lab_pin.sym} 360.0 -10.0 0 0 {name=l6 lab=SAEB}
C {devices/lab_pin.sym} 360.0 10.0 0 0 {name=l7 lab=Q[31:0]}
C {devices/lab_pin.sym} 360.0 30.0 0 0 {name=l8 lab=VDD}
C {devices/lab_pin.sym} 360.0 50.0 0 0 {name=l9 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=p10 lab=SAE}
C {devices/ipin.sym} -900 -260 0 0 {name=p11 lab=D[31]}
C {devices/ipin.sym} -900 -220 0 0 {name=p12 lab=D[30]}
C {devices/ipin.sym} -900 -180 0 0 {name=p13 lab=D[29]}
C {devices/ipin.sym} -900 -140 0 0 {name=p14 lab=D[28]}
C {devices/ipin.sym} -900 -100 0 0 {name=p15 lab=D[27]}
C {devices/ipin.sym} -900 -60 0 0 {name=p16 lab=D[26]}
C {devices/ipin.sym} -900 -20 0 0 {name=p17 lab=D[25]}
C {devices/ipin.sym} -900 20 0 0 {name=p18 lab=D[24]}
C {devices/ipin.sym} -900 60 0 0 {name=p19 lab=D[23]}
C {devices/ipin.sym} -900 100 0 0 {name=p20 lab=D[22]}
C {devices/ipin.sym} -900 140 0 0 {name=p21 lab=D[21]}
C {devices/ipin.sym} -900 180 0 0 {name=p22 lab=D[20]}
C {devices/ipin.sym} -900 220 0 0 {name=p23 lab=D[19]}
C {devices/ipin.sym} -900 260 0 0 {name=p24 lab=D[18]}
C {devices/ipin.sym} -900 300 0 0 {name=p25 lab=D[17]}
C {devices/ipin.sym} -900 340 0 0 {name=p26 lab=D[16]}
C {devices/ipin.sym} -900 380 0 0 {name=p27 lab=D[15]}
C {devices/ipin.sym} -900 420 0 0 {name=p28 lab=D[14]}
C {devices/ipin.sym} -900 460 0 0 {name=p29 lab=D[13]}
C {devices/ipin.sym} -900 500 0 0 {name=p30 lab=D[12]}
C {devices/ipin.sym} -900 540 0 0 {name=p31 lab=D[11]}
C {devices/ipin.sym} -900 580 0 0 {name=p32 lab=D[10]}
C {devices/ipin.sym} -900 620 0 0 {name=p33 lab=D[9]}
C {devices/ipin.sym} -900 660 0 0 {name=p34 lab=D[8]}
C {devices/ipin.sym} -900 700 0 0 {name=p35 lab=D[7]}
C {devices/ipin.sym} -900 740 0 0 {name=p36 lab=D[6]}
C {devices/ipin.sym} -900 780 0 0 {name=p37 lab=D[5]}
C {devices/ipin.sym} -900 820 0 0 {name=p38 lab=D[4]}
C {devices/ipin.sym} -900 860 0 0 {name=p39 lab=D[3]}
C {devices/ipin.sym} -900 900 0 0 {name=p40 lab=D[2]}
C {devices/ipin.sym} -900 940 0 0 {name=p41 lab=D[1]}
C {devices/ipin.sym} -900 980 0 0 {name=p42 lab=D[0]}
C {devices/opin.sym} -900 1020 0 0 {name=p43 lab=Q[31]}
C {devices/opin.sym} -900 1060 0 0 {name=p44 lab=Q[30]}
C {devices/opin.sym} -900 1100 0 0 {name=p45 lab=Q[29]}
C {devices/opin.sym} -900 1140 0 0 {name=p46 lab=Q[28]}
C {devices/opin.sym} -900 1180 0 0 {name=p47 lab=Q[27]}
C {devices/opin.sym} -900 1220 0 0 {name=p48 lab=Q[26]}
C {devices/opin.sym} -900 1260 0 0 {name=p49 lab=Q[25]}
C {devices/opin.sym} -900 1300 0 0 {name=p50 lab=Q[24]}
C {devices/opin.sym} -900 1340 0 0 {name=p51 lab=Q[23]}
C {devices/opin.sym} -900 1380 0 0 {name=p52 lab=Q[22]}
C {devices/opin.sym} -900 1420 0 0 {name=p53 lab=Q[21]}
C {devices/opin.sym} -900 1460 0 0 {name=p54 lab=Q[20]}
C {devices/opin.sym} -900 1500 0 0 {name=p55 lab=Q[19]}
C {devices/opin.sym} -900 1540 0 0 {name=p56 lab=Q[18]}
C {devices/opin.sym} -900 1580 0 0 {name=p57 lab=Q[17]}
C {devices/opin.sym} -900 1620 0 0 {name=p58 lab=Q[16]}
C {devices/opin.sym} -900 1660 0 0 {name=p59 lab=Q[15]}
C {devices/opin.sym} -900 1700 0 0 {name=p60 lab=Q[14]}
C {devices/opin.sym} -900 1740 0 0 {name=p61 lab=Q[13]}
C {devices/opin.sym} -900 1780 0 0 {name=p62 lab=Q[12]}
C {devices/opin.sym} -900 1820 0 0 {name=p63 lab=Q[11]}
C {devices/opin.sym} -900 1860 0 0 {name=p64 lab=Q[10]}
C {devices/opin.sym} -900 1900 0 0 {name=p65 lab=Q[9]}
C {devices/opin.sym} -900 1940 0 0 {name=p66 lab=Q[8]}
C {devices/opin.sym} -900 1980 0 0 {name=p67 lab=Q[7]}
C {devices/opin.sym} -900 2020 0 0 {name=p68 lab=Q[6]}
C {devices/opin.sym} -900 2060 0 0 {name=p69 lab=Q[5]}
C {devices/opin.sym} -900 2100 0 0 {name=p70 lab=Q[4]}
C {devices/opin.sym} -900 2140 0 0 {name=p71 lab=Q[3]}
C {devices/opin.sym} -900 2180 0 0 {name=p72 lab=Q[2]}
C {devices/opin.sym} -900 2220 0 0 {name=p73 lab=Q[1]}
C {devices/opin.sym} -900 2260 0 0 {name=p74 lab=Q[0]}
C {devices/iopin.sym} -900 2300 0 0 {name=p75 lab=VDD}
C {devices/iopin.sym} -900 2340 0 0 {name=p76 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* read-data output latch, transparent while SAE is high, holds the resolved value after SAE falls"}
