v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {gates/inv.sym} 0 0 0 0 {name=XCB}
C {devices/lab_pin.sym} -40.0 -30.0 0 0 {name=l0 lab=CLK}
C {devices/lab_pin.sym} -40.0 -10.0 0 0 {name=l1 lab=CLKB}
C {devices/lab_pin.sym} -40.0 10.0 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} -40.0 30.0 0 0 {name=l3 lab=VSS}
C {latches/dlatch.sym} 400 0 0 0 {name=XL[31:0]}
C {devices/lab_pin.sym} 360.0 -50.0 0 0 {name=l4 lab=D[31:0]}
C {devices/lab_pin.sym} 360.0 -30.0 0 0 {name=l5 lab=CLKB}
C {devices/lab_pin.sym} 360.0 -10.0 0 0 {name=l6 lab=CLK}
C {devices/lab_pin.sym} 360.0 10.0 0 0 {name=l7 lab=Q[31:0]}
C {devices/lab_pin.sym} 360.0 30.0 0 0 {name=l8 lab=VDD}
C {devices/lab_pin.sym} 360.0 50.0 0 0 {name=l9 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=pw46 lab=CLK}
C {devices/ipin.sym} -900 -260 0 0 {name=pw47 lab=D[31]}
C {devices/ipin.sym} -900 -220 0 0 {name=pw48 lab=D[30]}
C {devices/ipin.sym} -900 -180 0 0 {name=pw49 lab=D[29]}
C {devices/ipin.sym} -900 -140 0 0 {name=pw50 lab=D[28]}
C {devices/ipin.sym} -900 -100 0 0 {name=pw51 lab=D[27]}
C {devices/ipin.sym} -900 -60 0 0 {name=pw52 lab=D[26]}
C {devices/ipin.sym} -900 -20 0 0 {name=pw53 lab=D[25]}
C {devices/ipin.sym} -900 20 0 0 {name=pw54 lab=D[24]}
C {devices/ipin.sym} -900 60 0 0 {name=pw55 lab=D[23]}
C {devices/ipin.sym} -900 100 0 0 {name=pw56 lab=D[22]}
C {devices/ipin.sym} -900 140 0 0 {name=pw57 lab=D[21]}
C {devices/ipin.sym} -900 180 0 0 {name=pw58 lab=D[20]}
C {devices/ipin.sym} -900 220 0 0 {name=pw59 lab=D[19]}
C {devices/ipin.sym} -900 260 0 0 {name=pw60 lab=D[18]}
C {devices/ipin.sym} -900 300 0 0 {name=pw61 lab=D[17]}
C {devices/ipin.sym} -900 340 0 0 {name=pw62 lab=D[16]}
C {devices/ipin.sym} -900 380 0 0 {name=pw63 lab=D[15]}
C {devices/ipin.sym} -900 420 0 0 {name=pw64 lab=D[14]}
C {devices/ipin.sym} -900 460 0 0 {name=pw65 lab=D[13]}
C {devices/ipin.sym} -900 500 0 0 {name=pw66 lab=D[12]}
C {devices/ipin.sym} -900 540 0 0 {name=pw67 lab=D[11]}
C {devices/ipin.sym} -900 580 0 0 {name=pw68 lab=D[10]}
C {devices/ipin.sym} -900 620 0 0 {name=pw69 lab=D[9]}
C {devices/ipin.sym} -900 660 0 0 {name=pw70 lab=D[8]}
C {devices/ipin.sym} -900 700 0 0 {name=pw71 lab=D[7]}
C {devices/ipin.sym} -900 740 0 0 {name=pw72 lab=D[6]}
C {devices/ipin.sym} -900 780 0 0 {name=pw73 lab=D[5]}
C {devices/ipin.sym} -900 820 0 0 {name=pw74 lab=D[4]}
C {devices/ipin.sym} -900 860 0 0 {name=pw75 lab=D[3]}
C {devices/ipin.sym} -900 900 0 0 {name=pw76 lab=D[2]}
C {devices/ipin.sym} -900 940 0 0 {name=pw77 lab=D[1]}
C {devices/ipin.sym} -900 980 0 0 {name=pw78 lab=D[0]}
C {devices/ipin.sym} -900 1020 0 0 {name=pw79 lab=WEN[31]}
C {devices/ipin.sym} -900 1060 0 0 {name=pw80 lab=WEN[30]}
C {devices/ipin.sym} -900 1100 0 0 {name=pw81 lab=WEN[29]}
C {devices/ipin.sym} -900 1140 0 0 {name=pw82 lab=WEN[28]}
C {devices/ipin.sym} -900 1180 0 0 {name=pw83 lab=WEN[27]}
C {devices/ipin.sym} -900 1220 0 0 {name=pw84 lab=WEN[26]}
C {devices/ipin.sym} -900 1260 0 0 {name=pw85 lab=WEN[25]}
C {devices/ipin.sym} -900 1300 0 0 {name=pw86 lab=WEN[24]}
C {devices/ipin.sym} -900 1340 0 0 {name=pw87 lab=WEN[23]}
C {devices/ipin.sym} -900 1380 0 0 {name=pw88 lab=WEN[22]}
C {devices/ipin.sym} -900 1420 0 0 {name=pw89 lab=WEN[21]}
C {devices/ipin.sym} -900 1460 0 0 {name=pw90 lab=WEN[20]}
C {devices/ipin.sym} -900 1500 0 0 {name=pw91 lab=WEN[19]}
C {devices/ipin.sym} -900 1540 0 0 {name=pw92 lab=WEN[18]}
C {devices/ipin.sym} -900 1580 0 0 {name=pw93 lab=WEN[17]}
C {devices/ipin.sym} -900 1620 0 0 {name=pw94 lab=WEN[16]}
C {devices/ipin.sym} -900 1660 0 0 {name=pw95 lab=WEN[15]}
C {devices/ipin.sym} -900 1700 0 0 {name=pw96 lab=WEN[14]}
C {devices/ipin.sym} -900 1740 0 0 {name=pw97 lab=WEN[13]}
C {devices/ipin.sym} -900 1780 0 0 {name=pw98 lab=WEN[12]}
C {devices/ipin.sym} -900 1820 0 0 {name=pw99 lab=WEN[11]}
C {devices/ipin.sym} -900 1860 0 0 {name=pw100 lab=WEN[10]}
C {devices/ipin.sym} -900 1900 0 0 {name=pw101 lab=WEN[9]}
C {devices/ipin.sym} -900 1940 0 0 {name=pw102 lab=WEN[8]}
C {devices/ipin.sym} -900 1980 0 0 {name=pw103 lab=WEN[7]}
C {devices/ipin.sym} -900 2020 0 0 {name=pw104 lab=WEN[6]}
C {devices/ipin.sym} -900 2060 0 0 {name=pw105 lab=WEN[5]}
C {devices/ipin.sym} -900 2100 0 0 {name=pw106 lab=WEN[4]}
C {devices/ipin.sym} -900 2140 0 0 {name=pw107 lab=WEN[3]}
C {devices/ipin.sym} -900 2180 0 0 {name=pw108 lab=WEN[2]}
C {devices/ipin.sym} -900 2220 0 0 {name=pw109 lab=WEN[1]}
C {devices/ipin.sym} -900 2260 0 0 {name=pw110 lab=WEN[0]}
C {devices/opin.sym} -900 2300 0 0 {name=pw111 lab=Q[31]}
C {devices/opin.sym} -900 2340 0 0 {name=pw112 lab=Q[30]}
C {devices/opin.sym} -900 2380 0 0 {name=pw113 lab=Q[29]}
C {devices/opin.sym} -900 2420 0 0 {name=pw114 lab=Q[28]}
C {devices/opin.sym} -900 2460 0 0 {name=pw115 lab=Q[27]}
C {devices/opin.sym} -900 2500 0 0 {name=pw116 lab=Q[26]}
C {devices/opin.sym} -900 2540 0 0 {name=pw117 lab=Q[25]}
C {devices/opin.sym} -900 2580 0 0 {name=pw118 lab=Q[24]}
C {devices/opin.sym} -900 2620 0 0 {name=pw119 lab=Q[23]}
C {devices/opin.sym} -900 2660 0 0 {name=pw120 lab=Q[22]}
C {devices/opin.sym} -900 2700 0 0 {name=pw121 lab=Q[21]}
C {devices/opin.sym} -900 2740 0 0 {name=pw122 lab=Q[20]}
C {devices/opin.sym} -900 2780 0 0 {name=pw123 lab=Q[19]}
C {devices/opin.sym} -900 2820 0 0 {name=pw124 lab=Q[18]}
C {devices/opin.sym} -900 2860 0 0 {name=pw125 lab=Q[17]}
C {devices/opin.sym} -900 2900 0 0 {name=pw126 lab=Q[16]}
C {devices/opin.sym} -900 2940 0 0 {name=pw127 lab=Q[15]}
C {devices/opin.sym} -900 2980 0 0 {name=pw128 lab=Q[14]}
C {devices/opin.sym} -900 3020 0 0 {name=pw129 lab=Q[13]}
C {devices/opin.sym} -900 3060 0 0 {name=pw130 lab=Q[12]}
C {devices/opin.sym} -900 3100 0 0 {name=pw131 lab=Q[11]}
C {devices/opin.sym} -900 3140 0 0 {name=pw132 lab=Q[10]}
C {devices/opin.sym} -900 3180 0 0 {name=pw133 lab=Q[9]}
C {devices/opin.sym} -900 3220 0 0 {name=pw134 lab=Q[8]}
C {devices/opin.sym} -900 3260 0 0 {name=pw135 lab=Q[7]}
C {devices/opin.sym} -900 3300 0 0 {name=pw136 lab=Q[6]}
C {devices/opin.sym} -900 3340 0 0 {name=pw137 lab=Q[5]}
C {devices/opin.sym} -900 3380 0 0 {name=pw138 lab=Q[4]}
C {devices/opin.sym} -900 3420 0 0 {name=pw139 lab=Q[3]}
C {devices/opin.sym} -900 3460 0 0 {name=pw140 lab=Q[2]}
C {devices/opin.sym} -900 3500 0 0 {name=pw141 lab=Q[1]}
C {devices/opin.sym} -900 3540 0 0 {name=pw142 lab=Q[0]}
C {devices/opin.sym} -900 3580 0 0 {name=pw143 lab=WENL[31]}
C {devices/opin.sym} -900 3620 0 0 {name=pw144 lab=WENL[30]}
C {devices/opin.sym} -900 3660 0 0 {name=pw145 lab=WENL[29]}
C {devices/opin.sym} -900 3700 0 0 {name=pw146 lab=WENL[28]}
C {devices/opin.sym} -900 3740 0 0 {name=pw147 lab=WENL[27]}
C {devices/opin.sym} -900 3780 0 0 {name=pw148 lab=WENL[26]}
C {devices/opin.sym} -900 3820 0 0 {name=pw149 lab=WENL[25]}
C {devices/opin.sym} -900 3860 0 0 {name=pw150 lab=WENL[24]}
C {devices/opin.sym} -900 3900 0 0 {name=pw151 lab=WENL[23]}
C {devices/opin.sym} -900 3940 0 0 {name=pw152 lab=WENL[22]}
C {devices/opin.sym} -900 3980 0 0 {name=pw153 lab=WENL[21]}
C {devices/opin.sym} -900 4020 0 0 {name=pw154 lab=WENL[20]}
C {devices/opin.sym} -900 4060 0 0 {name=pw155 lab=WENL[19]}
C {devices/opin.sym} -900 4100 0 0 {name=pw156 lab=WENL[18]}
C {devices/opin.sym} -900 4140 0 0 {name=pw157 lab=WENL[17]}
C {devices/opin.sym} -900 4180 0 0 {name=pw158 lab=WENL[16]}
C {devices/opin.sym} -900 4220 0 0 {name=pw159 lab=WENL[15]}
C {devices/opin.sym} -900 4260 0 0 {name=pw160 lab=WENL[14]}
C {devices/opin.sym} -900 4300 0 0 {name=pw161 lab=WENL[13]}
C {devices/opin.sym} -900 4340 0 0 {name=pw162 lab=WENL[12]}
C {devices/opin.sym} -900 4380 0 0 {name=pw163 lab=WENL[11]}
C {devices/opin.sym} -900 4420 0 0 {name=pw164 lab=WENL[10]}
C {devices/opin.sym} -900 4460 0 0 {name=pw165 lab=WENL[9]}
C {devices/opin.sym} -900 4500 0 0 {name=pw166 lab=WENL[8]}
C {devices/opin.sym} -900 4540 0 0 {name=pw167 lab=WENL[7]}
C {devices/opin.sym} -900 4580 0 0 {name=pw168 lab=WENL[6]}
C {devices/opin.sym} -900 4620 0 0 {name=pw169 lab=WENL[5]}
C {devices/opin.sym} -900 4660 0 0 {name=pw170 lab=WENL[4]}
C {devices/opin.sym} -900 4700 0 0 {name=pw171 lab=WENL[3]}
C {devices/opin.sym} -900 4740 0 0 {name=pw172 lab=WENL[2]}
C {devices/opin.sym} -900 4780 0 0 {name=pw173 lab=WENL[1]}
C {devices/opin.sym} -900 4820 0 0 {name=pw174 lab=WENL[0]}
C {devices/iopin.sym} -900 4860 0 0 {name=pw175 lab=VDD}
C {devices/iopin.sym} -900 4900 0 0 {name=pw176 lab=VSS}
C {latches/dlatch.sym} 400 300 0 0 {name=XM[31:0]}
C {devices/lab_pin.sym} 360 250 0 0 {name=lw177 lab=WEN[31:0]}
C {devices/lab_pin.sym} 360 270 0 0 {name=lw178 lab=CLKB}
C {devices/lab_pin.sym} 360 290 0 0 {name=lw179 lab=CLK}
C {devices/lab_pin.sym} 360 310 0 0 {name=lw180 lab=WENL[31:0]}
C {devices/lab_pin.sym} 360 330 0 0 {name=lw181 lab=VDD}
C {devices/lab_pin.sym} 360 350 0 0 {name=lw182 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* write-data input latch, transparent while CLK is low, holds while CLK is high"}
