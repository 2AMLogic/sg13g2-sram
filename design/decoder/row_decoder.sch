v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {decoder/predec3.sym} 0 0 0 0 {name=XP3}
C {devices/lab_pin.sym} -40.0 -120.0 0 0 {name=l0 lab=A[2]}
C {devices/lab_pin.sym} -40.0 -100.0 0 0 {name=l1 lab=A[1]}
C {devices/lab_pin.sym} -40.0 -80.0 0 0 {name=l2 lab=A[0]}
C {devices/lab_pin.sym} -40.0 -60.0 0 0 {name=l3 lab=X[7]}
C {devices/lab_pin.sym} -40.0 -40.0 0 0 {name=l4 lab=X[6]}
C {devices/lab_pin.sym} -40.0 -20.0 0 0 {name=l5 lab=X[5]}
C {devices/lab_pin.sym} -40.0 0.0 0 0 {name=l6 lab=X[4]}
C {devices/lab_pin.sym} -40.0 20.0 0 0 {name=l7 lab=X[3]}
C {devices/lab_pin.sym} -40.0 40.0 0 0 {name=l8 lab=X[2]}
C {devices/lab_pin.sym} -40.0 60.0 0 0 {name=l9 lab=X[1]}
C {devices/lab_pin.sym} -40.0 80.0 0 0 {name=l10 lab=X[0]}
C {devices/lab_pin.sym} -40.0 100.0 0 0 {name=l11 lab=VDD}
C {devices/lab_pin.sym} -40.0 120.0 0 0 {name=l12 lab=VSS}
C {decoder/predec4.sym} 400 0 0 0 {name=XP4}
C {devices/lab_pin.sym} 360.0 -210.0 0 0 {name=l13 lab=A[6]}
C {devices/lab_pin.sym} 360.0 -190.0 0 0 {name=l14 lab=A[5]}
C {devices/lab_pin.sym} 360.0 -170.0 0 0 {name=l15 lab=A[4]}
C {devices/lab_pin.sym} 360.0 -150.0 0 0 {name=l16 lab=A[3]}
C {devices/lab_pin.sym} 360.0 -130.0 0 0 {name=l17 lab=Y[15]}
C {devices/lab_pin.sym} 360.0 -110.0 0 0 {name=l18 lab=Y[14]}
C {devices/lab_pin.sym} 360.0 -90.0 0 0 {name=l19 lab=Y[13]}
C {devices/lab_pin.sym} 360.0 -70.0 0 0 {name=l20 lab=Y[12]}
C {devices/lab_pin.sym} 360.0 -50.0 0 0 {name=l21 lab=Y[11]}
C {devices/lab_pin.sym} 360.0 -30.0 0 0 {name=l22 lab=Y[10]}
C {devices/lab_pin.sym} 360.0 -10.0 0 0 {name=l23 lab=Y[9]}
C {devices/lab_pin.sym} 360.0 10.0 0 0 {name=l24 lab=Y[8]}
C {devices/lab_pin.sym} 360.0 30.0 0 0 {name=l25 lab=Y[7]}
C {devices/lab_pin.sym} 360.0 50.0 0 0 {name=l26 lab=Y[6]}
C {devices/lab_pin.sym} 360.0 70.0 0 0 {name=l27 lab=Y[5]}
C {devices/lab_pin.sym} 360.0 90.0 0 0 {name=l28 lab=Y[4]}
C {devices/lab_pin.sym} 360.0 110.0 0 0 {name=l29 lab=Y[3]}
C {devices/lab_pin.sym} 360.0 130.0 0 0 {name=l30 lab=Y[2]}
C {devices/lab_pin.sym} 360.0 150.0 0 0 {name=l31 lab=Y[1]}
C {devices/lab_pin.sym} 360.0 170.0 0 0 {name=l32 lab=Y[0]}
C {devices/lab_pin.sym} 360.0 190.0 0 0 {name=l33 lab=VDD}
C {devices/lab_pin.sym} 360.0 210.0 0 0 {name=l34 lab=VSS}
C {decoder/wl_drivers.sym} 800 0 0 0 {name=XWD}
C {devices/lab_pin.sym} 760.0 -1540.0 0 0 {name=l35 lab=X[7]}
C {devices/lab_pin.sym} 760.0 -1520.0 0 0 {name=l36 lab=X[6]}
C {devices/lab_pin.sym} 760.0 -1500.0 0 0 {name=l37 lab=X[5]}
C {devices/lab_pin.sym} 760.0 -1480.0 0 0 {name=l38 lab=X[4]}
C {devices/lab_pin.sym} 760.0 -1460.0 0 0 {name=l39 lab=X[3]}
C {devices/lab_pin.sym} 760.0 -1440.0 0 0 {name=l40 lab=X[2]}
C {devices/lab_pin.sym} 760.0 -1420.0 0 0 {name=l41 lab=X[1]}
C {devices/lab_pin.sym} 760.0 -1400.0 0 0 {name=l42 lab=X[0]}
C {devices/lab_pin.sym} 760.0 -1380.0 0 0 {name=l43 lab=Y[15]}
C {devices/lab_pin.sym} 760.0 -1360.0 0 0 {name=l44 lab=Y[14]}
C {devices/lab_pin.sym} 760.0 -1340.0 0 0 {name=l45 lab=Y[13]}
C {devices/lab_pin.sym} 760.0 -1320.0 0 0 {name=l46 lab=Y[12]}
C {devices/lab_pin.sym} 760.0 -1300.0 0 0 {name=l47 lab=Y[11]}
C {devices/lab_pin.sym} 760.0 -1280.0 0 0 {name=l48 lab=Y[10]}
C {devices/lab_pin.sym} 760.0 -1260.0 0 0 {name=l49 lab=Y[9]}
C {devices/lab_pin.sym} 760.0 -1240.0 0 0 {name=l50 lab=Y[8]}
C {devices/lab_pin.sym} 760.0 -1220.0 0 0 {name=l51 lab=Y[7]}
C {devices/lab_pin.sym} 760.0 -1200.0 0 0 {name=l52 lab=Y[6]}
C {devices/lab_pin.sym} 760.0 -1180.0 0 0 {name=l53 lab=Y[5]}
C {devices/lab_pin.sym} 760.0 -1160.0 0 0 {name=l54 lab=Y[4]}
C {devices/lab_pin.sym} 760.0 -1140.0 0 0 {name=l55 lab=Y[3]}
C {devices/lab_pin.sym} 760.0 -1120.0 0 0 {name=l56 lab=Y[2]}
C {devices/lab_pin.sym} 760.0 -1100.0 0 0 {name=l57 lab=Y[1]}
C {devices/lab_pin.sym} 760.0 -1080.0 0 0 {name=l58 lab=Y[0]}
C {devices/lab_pin.sym} 760.0 -1060.0 0 0 {name=l59 lab=WLEN}
C {devices/lab_pin.sym} 760.0 -1040.0 0 0 {name=l60 lab=WL[127]}
C {devices/lab_pin.sym} 760.0 -1020.0 0 0 {name=l61 lab=WL[126]}
C {devices/lab_pin.sym} 760.0 -1000.0 0 0 {name=l62 lab=WL[125]}
C {devices/lab_pin.sym} 760.0 -980.0 0 0 {name=l63 lab=WL[124]}
C {devices/lab_pin.sym} 760.0 -960.0 0 0 {name=l64 lab=WL[123]}
C {devices/lab_pin.sym} 760.0 -940.0 0 0 {name=l65 lab=WL[122]}
C {devices/lab_pin.sym} 760.0 -920.0 0 0 {name=l66 lab=WL[121]}
C {devices/lab_pin.sym} 760.0 -900.0 0 0 {name=l67 lab=WL[120]}
C {devices/lab_pin.sym} 760.0 -880.0 0 0 {name=l68 lab=WL[119]}
C {devices/lab_pin.sym} 760.0 -860.0 0 0 {name=l69 lab=WL[118]}
C {devices/lab_pin.sym} 760.0 -840.0 0 0 {name=l70 lab=WL[117]}
C {devices/lab_pin.sym} 760.0 -820.0 0 0 {name=l71 lab=WL[116]}
C {devices/lab_pin.sym} 760.0 -800.0 0 0 {name=l72 lab=WL[115]}
C {devices/lab_pin.sym} 760.0 -780.0 0 0 {name=l73 lab=WL[114]}
C {devices/lab_pin.sym} 760.0 -760.0 0 0 {name=l74 lab=WL[113]}
C {devices/lab_pin.sym} 760.0 -740.0 0 0 {name=l75 lab=WL[112]}
C {devices/lab_pin.sym} 760.0 -720.0 0 0 {name=l76 lab=WL[111]}
C {devices/lab_pin.sym} 760.0 -700.0 0 0 {name=l77 lab=WL[110]}
C {devices/lab_pin.sym} 760.0 -680.0 0 0 {name=l78 lab=WL[109]}
C {devices/lab_pin.sym} 760.0 -660.0 0 0 {name=l79 lab=WL[108]}
C {devices/lab_pin.sym} 760.0 -640.0 0 0 {name=l80 lab=WL[107]}
C {devices/lab_pin.sym} 760.0 -620.0 0 0 {name=l81 lab=WL[106]}
C {devices/lab_pin.sym} 760.0 -600.0 0 0 {name=l82 lab=WL[105]}
C {devices/lab_pin.sym} 760.0 -580.0 0 0 {name=l83 lab=WL[104]}
C {devices/lab_pin.sym} 760.0 -560.0 0 0 {name=l84 lab=WL[103]}
C {devices/lab_pin.sym} 760.0 -540.0 0 0 {name=l85 lab=WL[102]}
C {devices/lab_pin.sym} 760.0 -520.0 0 0 {name=l86 lab=WL[101]}
C {devices/lab_pin.sym} 760.0 -500.0 0 0 {name=l87 lab=WL[100]}
C {devices/lab_pin.sym} 760.0 -480.0 0 0 {name=l88 lab=WL[99]}
C {devices/lab_pin.sym} 760.0 -460.0 0 0 {name=l89 lab=WL[98]}
C {devices/lab_pin.sym} 760.0 -440.0 0 0 {name=l90 lab=WL[97]}
C {devices/lab_pin.sym} 760.0 -420.0 0 0 {name=l91 lab=WL[96]}
C {devices/lab_pin.sym} 760.0 -400.0 0 0 {name=l92 lab=WL[95]}
C {devices/lab_pin.sym} 760.0 -380.0 0 0 {name=l93 lab=WL[94]}
C {devices/lab_pin.sym} 760.0 -360.0 0 0 {name=l94 lab=WL[93]}
C {devices/lab_pin.sym} 760.0 -340.0 0 0 {name=l95 lab=WL[92]}
C {devices/lab_pin.sym} 760.0 -320.0 0 0 {name=l96 lab=WL[91]}
C {devices/lab_pin.sym} 760.0 -300.0 0 0 {name=l97 lab=WL[90]}
C {devices/lab_pin.sym} 760.0 -280.0 0 0 {name=l98 lab=WL[89]}
C {devices/lab_pin.sym} 760.0 -260.0 0 0 {name=l99 lab=WL[88]}
C {devices/lab_pin.sym} 760.0 -240.0 0 0 {name=l100 lab=WL[87]}
C {devices/lab_pin.sym} 760.0 -220.0 0 0 {name=l101 lab=WL[86]}
C {devices/lab_pin.sym} 760.0 -200.0 0 0 {name=l102 lab=WL[85]}
C {devices/lab_pin.sym} 760.0 -180.0 0 0 {name=l103 lab=WL[84]}
C {devices/lab_pin.sym} 760.0 -160.0 0 0 {name=l104 lab=WL[83]}
C {devices/lab_pin.sym} 760.0 -140.0 0 0 {name=l105 lab=WL[82]}
C {devices/lab_pin.sym} 760.0 -120.0 0 0 {name=l106 lab=WL[81]}
C {devices/lab_pin.sym} 760.0 -100.0 0 0 {name=l107 lab=WL[80]}
C {devices/lab_pin.sym} 760.0 -80.0 0 0 {name=l108 lab=WL[79]}
C {devices/lab_pin.sym} 760.0 -60.0 0 0 {name=l109 lab=WL[78]}
C {devices/lab_pin.sym} 760.0 -40.0 0 0 {name=l110 lab=WL[77]}
C {devices/lab_pin.sym} 760.0 -20.0 0 0 {name=l111 lab=WL[76]}
C {devices/lab_pin.sym} 760.0 0.0 0 0 {name=l112 lab=WL[75]}
C {devices/lab_pin.sym} 760.0 20.0 0 0 {name=l113 lab=WL[74]}
C {devices/lab_pin.sym} 760.0 40.0 0 0 {name=l114 lab=WL[73]}
C {devices/lab_pin.sym} 760.0 60.0 0 0 {name=l115 lab=WL[72]}
C {devices/lab_pin.sym} 760.0 80.0 0 0 {name=l116 lab=WL[71]}
C {devices/lab_pin.sym} 760.0 100.0 0 0 {name=l117 lab=WL[70]}
C {devices/lab_pin.sym} 760.0 120.0 0 0 {name=l118 lab=WL[69]}
C {devices/lab_pin.sym} 760.0 140.0 0 0 {name=l119 lab=WL[68]}
C {devices/lab_pin.sym} 760.0 160.0 0 0 {name=l120 lab=WL[67]}
C {devices/lab_pin.sym} 760.0 180.0 0 0 {name=l121 lab=WL[66]}
C {devices/lab_pin.sym} 760.0 200.0 0 0 {name=l122 lab=WL[65]}
C {devices/lab_pin.sym} 760.0 220.0 0 0 {name=l123 lab=WL[64]}
C {devices/lab_pin.sym} 760.0 240.0 0 0 {name=l124 lab=WL[63]}
C {devices/lab_pin.sym} 760.0 260.0 0 0 {name=l125 lab=WL[62]}
C {devices/lab_pin.sym} 760.0 280.0 0 0 {name=l126 lab=WL[61]}
C {devices/lab_pin.sym} 760.0 300.0 0 0 {name=l127 lab=WL[60]}
C {devices/lab_pin.sym} 760.0 320.0 0 0 {name=l128 lab=WL[59]}
C {devices/lab_pin.sym} 760.0 340.0 0 0 {name=l129 lab=WL[58]}
C {devices/lab_pin.sym} 760.0 360.0 0 0 {name=l130 lab=WL[57]}
C {devices/lab_pin.sym} 760.0 380.0 0 0 {name=l131 lab=WL[56]}
C {devices/lab_pin.sym} 760.0 400.0 0 0 {name=l132 lab=WL[55]}
C {devices/lab_pin.sym} 760.0 420.0 0 0 {name=l133 lab=WL[54]}
C {devices/lab_pin.sym} 760.0 440.0 0 0 {name=l134 lab=WL[53]}
C {devices/lab_pin.sym} 760.0 460.0 0 0 {name=l135 lab=WL[52]}
C {devices/lab_pin.sym} 760.0 480.0 0 0 {name=l136 lab=WL[51]}
C {devices/lab_pin.sym} 760.0 500.0 0 0 {name=l137 lab=WL[50]}
C {devices/lab_pin.sym} 760.0 520.0 0 0 {name=l138 lab=WL[49]}
C {devices/lab_pin.sym} 760.0 540.0 0 0 {name=l139 lab=WL[48]}
C {devices/lab_pin.sym} 760.0 560.0 0 0 {name=l140 lab=WL[47]}
C {devices/lab_pin.sym} 760.0 580.0 0 0 {name=l141 lab=WL[46]}
C {devices/lab_pin.sym} 760.0 600.0 0 0 {name=l142 lab=WL[45]}
C {devices/lab_pin.sym} 760.0 620.0 0 0 {name=l143 lab=WL[44]}
C {devices/lab_pin.sym} 760.0 640.0 0 0 {name=l144 lab=WL[43]}
C {devices/lab_pin.sym} 760.0 660.0 0 0 {name=l145 lab=WL[42]}
C {devices/lab_pin.sym} 760.0 680.0 0 0 {name=l146 lab=WL[41]}
C {devices/lab_pin.sym} 760.0 700.0 0 0 {name=l147 lab=WL[40]}
C {devices/lab_pin.sym} 760.0 720.0 0 0 {name=l148 lab=WL[39]}
C {devices/lab_pin.sym} 760.0 740.0 0 0 {name=l149 lab=WL[38]}
C {devices/lab_pin.sym} 760.0 760.0 0 0 {name=l150 lab=WL[37]}
C {devices/lab_pin.sym} 760.0 780.0 0 0 {name=l151 lab=WL[36]}
C {devices/lab_pin.sym} 760.0 800.0 0 0 {name=l152 lab=WL[35]}
C {devices/lab_pin.sym} 760.0 820.0 0 0 {name=l153 lab=WL[34]}
C {devices/lab_pin.sym} 760.0 840.0 0 0 {name=l154 lab=WL[33]}
C {devices/lab_pin.sym} 760.0 860.0 0 0 {name=l155 lab=WL[32]}
C {devices/lab_pin.sym} 760.0 880.0 0 0 {name=l156 lab=WL[31]}
C {devices/lab_pin.sym} 760.0 900.0 0 0 {name=l157 lab=WL[30]}
C {devices/lab_pin.sym} 760.0 920.0 0 0 {name=l158 lab=WL[29]}
C {devices/lab_pin.sym} 760.0 940.0 0 0 {name=l159 lab=WL[28]}
C {devices/lab_pin.sym} 760.0 960.0 0 0 {name=l160 lab=WL[27]}
C {devices/lab_pin.sym} 760.0 980.0 0 0 {name=l161 lab=WL[26]}
C {devices/lab_pin.sym} 760.0 1000.0 0 0 {name=l162 lab=WL[25]}
C {devices/lab_pin.sym} 760.0 1020.0 0 0 {name=l163 lab=WL[24]}
C {devices/lab_pin.sym} 760.0 1040.0 0 0 {name=l164 lab=WL[23]}
C {devices/lab_pin.sym} 760.0 1060.0 0 0 {name=l165 lab=WL[22]}
C {devices/lab_pin.sym} 760.0 1080.0 0 0 {name=l166 lab=WL[21]}
C {devices/lab_pin.sym} 760.0 1100.0 0 0 {name=l167 lab=WL[20]}
C {devices/lab_pin.sym} 760.0 1120.0 0 0 {name=l168 lab=WL[19]}
C {devices/lab_pin.sym} 760.0 1140.0 0 0 {name=l169 lab=WL[18]}
C {devices/lab_pin.sym} 760.0 1160.0 0 0 {name=l170 lab=WL[17]}
C {devices/lab_pin.sym} 760.0 1180.0 0 0 {name=l171 lab=WL[16]}
C {devices/lab_pin.sym} 760.0 1200.0 0 0 {name=l172 lab=WL[15]}
C {devices/lab_pin.sym} 760.0 1220.0 0 0 {name=l173 lab=WL[14]}
C {devices/lab_pin.sym} 760.0 1240.0 0 0 {name=l174 lab=WL[13]}
C {devices/lab_pin.sym} 760.0 1260.0 0 0 {name=l175 lab=WL[12]}
C {devices/lab_pin.sym} 760.0 1280.0 0 0 {name=l176 lab=WL[11]}
C {devices/lab_pin.sym} 760.0 1300.0 0 0 {name=l177 lab=WL[10]}
C {devices/lab_pin.sym} 760.0 1320.0 0 0 {name=l178 lab=WL[9]}
C {devices/lab_pin.sym} 760.0 1340.0 0 0 {name=l179 lab=WL[8]}
C {devices/lab_pin.sym} 760.0 1360.0 0 0 {name=l180 lab=WL[7]}
C {devices/lab_pin.sym} 760.0 1380.0 0 0 {name=l181 lab=WL[6]}
C {devices/lab_pin.sym} 760.0 1400.0 0 0 {name=l182 lab=WL[5]}
C {devices/lab_pin.sym} 760.0 1420.0 0 0 {name=l183 lab=WL[4]}
C {devices/lab_pin.sym} 760.0 1440.0 0 0 {name=l184 lab=WL[3]}
C {devices/lab_pin.sym} 760.0 1460.0 0 0 {name=l185 lab=WL[2]}
C {devices/lab_pin.sym} 760.0 1480.0 0 0 {name=l186 lab=WL[1]}
C {devices/lab_pin.sym} 760.0 1500.0 0 0 {name=l187 lab=WL[0]}
C {devices/lab_pin.sym} 760.0 1520.0 0 0 {name=l188 lab=VDD}
C {devices/lab_pin.sym} 760.0 1540.0 0 0 {name=l189 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=p190 lab=A[6]}
C {devices/ipin.sym} -900 -260 0 0 {name=p191 lab=A[5]}
C {devices/ipin.sym} -900 -220 0 0 {name=p192 lab=A[4]}
C {devices/ipin.sym} -900 -180 0 0 {name=p193 lab=A[3]}
C {devices/ipin.sym} -900 -140 0 0 {name=p194 lab=A[2]}
C {devices/ipin.sym} -900 -100 0 0 {name=p195 lab=A[1]}
C {devices/ipin.sym} -900 -60 0 0 {name=p196 lab=A[0]}
C {devices/ipin.sym} -900 -20 0 0 {name=p197 lab=WLEN}
C {devices/opin.sym} -900 20 0 0 {name=p198 lab=WL[127]}
C {devices/opin.sym} -900 60 0 0 {name=p199 lab=WL[126]}
C {devices/opin.sym} -900 100 0 0 {name=p200 lab=WL[125]}
C {devices/opin.sym} -900 140 0 0 {name=p201 lab=WL[124]}
C {devices/opin.sym} -900 180 0 0 {name=p202 lab=WL[123]}
C {devices/opin.sym} -900 220 0 0 {name=p203 lab=WL[122]}
C {devices/opin.sym} -900 260 0 0 {name=p204 lab=WL[121]}
C {devices/opin.sym} -900 300 0 0 {name=p205 lab=WL[120]}
C {devices/opin.sym} -900 340 0 0 {name=p206 lab=WL[119]}
C {devices/opin.sym} -900 380 0 0 {name=p207 lab=WL[118]}
C {devices/opin.sym} -900 420 0 0 {name=p208 lab=WL[117]}
C {devices/opin.sym} -900 460 0 0 {name=p209 lab=WL[116]}
C {devices/opin.sym} -900 500 0 0 {name=p210 lab=WL[115]}
C {devices/opin.sym} -900 540 0 0 {name=p211 lab=WL[114]}
C {devices/opin.sym} -900 580 0 0 {name=p212 lab=WL[113]}
C {devices/opin.sym} -900 620 0 0 {name=p213 lab=WL[112]}
C {devices/opin.sym} -900 660 0 0 {name=p214 lab=WL[111]}
C {devices/opin.sym} -900 700 0 0 {name=p215 lab=WL[110]}
C {devices/opin.sym} -900 740 0 0 {name=p216 lab=WL[109]}
C {devices/opin.sym} -900 780 0 0 {name=p217 lab=WL[108]}
C {devices/opin.sym} -900 820 0 0 {name=p218 lab=WL[107]}
C {devices/opin.sym} -900 860 0 0 {name=p219 lab=WL[106]}
C {devices/opin.sym} -900 900 0 0 {name=p220 lab=WL[105]}
C {devices/opin.sym} -900 940 0 0 {name=p221 lab=WL[104]}
C {devices/opin.sym} -900 980 0 0 {name=p222 lab=WL[103]}
C {devices/opin.sym} -900 1020 0 0 {name=p223 lab=WL[102]}
C {devices/opin.sym} -900 1060 0 0 {name=p224 lab=WL[101]}
C {devices/opin.sym} -900 1100 0 0 {name=p225 lab=WL[100]}
C {devices/opin.sym} -900 1140 0 0 {name=p226 lab=WL[99]}
C {devices/opin.sym} -900 1180 0 0 {name=p227 lab=WL[98]}
C {devices/opin.sym} -900 1220 0 0 {name=p228 lab=WL[97]}
C {devices/opin.sym} -900 1260 0 0 {name=p229 lab=WL[96]}
C {devices/opin.sym} -900 1300 0 0 {name=p230 lab=WL[95]}
C {devices/opin.sym} -900 1340 0 0 {name=p231 lab=WL[94]}
C {devices/opin.sym} -900 1380 0 0 {name=p232 lab=WL[93]}
C {devices/opin.sym} -900 1420 0 0 {name=p233 lab=WL[92]}
C {devices/opin.sym} -900 1460 0 0 {name=p234 lab=WL[91]}
C {devices/opin.sym} -900 1500 0 0 {name=p235 lab=WL[90]}
C {devices/opin.sym} -900 1540 0 0 {name=p236 lab=WL[89]}
C {devices/opin.sym} -900 1580 0 0 {name=p237 lab=WL[88]}
C {devices/opin.sym} -900 1620 0 0 {name=p238 lab=WL[87]}
C {devices/opin.sym} -900 1660 0 0 {name=p239 lab=WL[86]}
C {devices/opin.sym} -900 1700 0 0 {name=p240 lab=WL[85]}
C {devices/opin.sym} -900 1740 0 0 {name=p241 lab=WL[84]}
C {devices/opin.sym} -900 1780 0 0 {name=p242 lab=WL[83]}
C {devices/opin.sym} -900 1820 0 0 {name=p243 lab=WL[82]}
C {devices/opin.sym} -900 1860 0 0 {name=p244 lab=WL[81]}
C {devices/opin.sym} -900 1900 0 0 {name=p245 lab=WL[80]}
C {devices/opin.sym} -900 1940 0 0 {name=p246 lab=WL[79]}
C {devices/opin.sym} -900 1980 0 0 {name=p247 lab=WL[78]}
C {devices/opin.sym} -900 2020 0 0 {name=p248 lab=WL[77]}
C {devices/opin.sym} -900 2060 0 0 {name=p249 lab=WL[76]}
C {devices/opin.sym} -900 2100 0 0 {name=p250 lab=WL[75]}
C {devices/opin.sym} -900 2140 0 0 {name=p251 lab=WL[74]}
C {devices/opin.sym} -900 2180 0 0 {name=p252 lab=WL[73]}
C {devices/opin.sym} -900 2220 0 0 {name=p253 lab=WL[72]}
C {devices/opin.sym} -900 2260 0 0 {name=p254 lab=WL[71]}
C {devices/opin.sym} -900 2300 0 0 {name=p255 lab=WL[70]}
C {devices/opin.sym} -900 2340 0 0 {name=p256 lab=WL[69]}
C {devices/opin.sym} -900 2380 0 0 {name=p257 lab=WL[68]}
C {devices/opin.sym} -900 2420 0 0 {name=p258 lab=WL[67]}
C {devices/opin.sym} -900 2460 0 0 {name=p259 lab=WL[66]}
C {devices/opin.sym} -900 2500 0 0 {name=p260 lab=WL[65]}
C {devices/opin.sym} -900 2540 0 0 {name=p261 lab=WL[64]}
C {devices/opin.sym} -900 2580 0 0 {name=p262 lab=WL[63]}
C {devices/opin.sym} -900 2620 0 0 {name=p263 lab=WL[62]}
C {devices/opin.sym} -900 2660 0 0 {name=p264 lab=WL[61]}
C {devices/opin.sym} -900 2700 0 0 {name=p265 lab=WL[60]}
C {devices/opin.sym} -900 2740 0 0 {name=p266 lab=WL[59]}
C {devices/opin.sym} -900 2780 0 0 {name=p267 lab=WL[58]}
C {devices/opin.sym} -900 2820 0 0 {name=p268 lab=WL[57]}
C {devices/opin.sym} -900 2860 0 0 {name=p269 lab=WL[56]}
C {devices/opin.sym} -900 2900 0 0 {name=p270 lab=WL[55]}
C {devices/opin.sym} -900 2940 0 0 {name=p271 lab=WL[54]}
C {devices/opin.sym} -900 2980 0 0 {name=p272 lab=WL[53]}
C {devices/opin.sym} -900 3020 0 0 {name=p273 lab=WL[52]}
C {devices/opin.sym} -900 3060 0 0 {name=p274 lab=WL[51]}
C {devices/opin.sym} -900 3100 0 0 {name=p275 lab=WL[50]}
C {devices/opin.sym} -900 3140 0 0 {name=p276 lab=WL[49]}
C {devices/opin.sym} -900 3180 0 0 {name=p277 lab=WL[48]}
C {devices/opin.sym} -900 3220 0 0 {name=p278 lab=WL[47]}
C {devices/opin.sym} -900 3260 0 0 {name=p279 lab=WL[46]}
C {devices/opin.sym} -900 3300 0 0 {name=p280 lab=WL[45]}
C {devices/opin.sym} -900 3340 0 0 {name=p281 lab=WL[44]}
C {devices/opin.sym} -900 3380 0 0 {name=p282 lab=WL[43]}
C {devices/opin.sym} -900 3420 0 0 {name=p283 lab=WL[42]}
C {devices/opin.sym} -900 3460 0 0 {name=p284 lab=WL[41]}
C {devices/opin.sym} -900 3500 0 0 {name=p285 lab=WL[40]}
C {devices/opin.sym} -900 3540 0 0 {name=p286 lab=WL[39]}
C {devices/opin.sym} -900 3580 0 0 {name=p287 lab=WL[38]}
C {devices/opin.sym} -900 3620 0 0 {name=p288 lab=WL[37]}
C {devices/opin.sym} -900 3660 0 0 {name=p289 lab=WL[36]}
C {devices/opin.sym} -900 3700 0 0 {name=p290 lab=WL[35]}
C {devices/opin.sym} -900 3740 0 0 {name=p291 lab=WL[34]}
C {devices/opin.sym} -900 3780 0 0 {name=p292 lab=WL[33]}
C {devices/opin.sym} -900 3820 0 0 {name=p293 lab=WL[32]}
C {devices/opin.sym} -900 3860 0 0 {name=p294 lab=WL[31]}
C {devices/opin.sym} -900 3900 0 0 {name=p295 lab=WL[30]}
C {devices/opin.sym} -900 3940 0 0 {name=p296 lab=WL[29]}
C {devices/opin.sym} -900 3980 0 0 {name=p297 lab=WL[28]}
C {devices/opin.sym} -900 4020 0 0 {name=p298 lab=WL[27]}
C {devices/opin.sym} -900 4060 0 0 {name=p299 lab=WL[26]}
C {devices/opin.sym} -900 4100 0 0 {name=p300 lab=WL[25]}
C {devices/opin.sym} -900 4140 0 0 {name=p301 lab=WL[24]}
C {devices/opin.sym} -900 4180 0 0 {name=p302 lab=WL[23]}
C {devices/opin.sym} -900 4220 0 0 {name=p303 lab=WL[22]}
C {devices/opin.sym} -900 4260 0 0 {name=p304 lab=WL[21]}
C {devices/opin.sym} -900 4300 0 0 {name=p305 lab=WL[20]}
C {devices/opin.sym} -900 4340 0 0 {name=p306 lab=WL[19]}
C {devices/opin.sym} -900 4380 0 0 {name=p307 lab=WL[18]}
C {devices/opin.sym} -900 4420 0 0 {name=p308 lab=WL[17]}
C {devices/opin.sym} -900 4460 0 0 {name=p309 lab=WL[16]}
C {devices/opin.sym} -900 4500 0 0 {name=p310 lab=WL[15]}
C {devices/opin.sym} -900 4540 0 0 {name=p311 lab=WL[14]}
C {devices/opin.sym} -900 4580 0 0 {name=p312 lab=WL[13]}
C {devices/opin.sym} -900 4620 0 0 {name=p313 lab=WL[12]}
C {devices/opin.sym} -900 4660 0 0 {name=p314 lab=WL[11]}
C {devices/opin.sym} -900 4700 0 0 {name=p315 lab=WL[10]}
C {devices/opin.sym} -900 4740 0 0 {name=p316 lab=WL[9]}
C {devices/opin.sym} -900 4780 0 0 {name=p317 lab=WL[8]}
C {devices/opin.sym} -900 4820 0 0 {name=p318 lab=WL[7]}
C {devices/opin.sym} -900 4860 0 0 {name=p319 lab=WL[6]}
C {devices/opin.sym} -900 4900 0 0 {name=p320 lab=WL[5]}
C {devices/opin.sym} -900 4940 0 0 {name=p321 lab=WL[4]}
C {devices/opin.sym} -900 4980 0 0 {name=p322 lab=WL[3]}
C {devices/opin.sym} -900 5020 0 0 {name=p323 lab=WL[2]}
C {devices/opin.sym} -900 5060 0 0 {name=p324 lab=WL[1]}
C {devices/opin.sym} -900 5100 0 0 {name=p325 lab=WL[0]}
C {devices/iopin.sym} -900 5140 0 0 {name=p326 lab=VDD}
C {devices/iopin.sym} -900 5180 0 0 {name=p327 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* 7-bit row decoder: A[2:0] -> X (8), A[6:3] -> Y (16), WL[8*j+k] = X[k] & Y[j] & WLEN"}
