v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {decoder/wl_driver.sym} 0 0 0 0 {name=XD[127:0]}
C {devices/lab_pin.sym} -40.0 -50.0 0 0 {name=l0 lab=X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0],X[7],X[6],X[5],X[4],X[3],X[2],X[1],X[0]}
C {devices/lab_pin.sym} -40.0 -30.0 0 0 {name=l1 lab=Y[15],Y[15],Y[15],Y[15],Y[15],Y[15],Y[15],Y[15],Y[14],Y[14],Y[14],Y[14],Y[14],Y[14],Y[14],Y[14],Y[13],Y[13],Y[13],Y[13],Y[13],Y[13],Y[13],Y[13],Y[12],Y[12],Y[12],Y[12],Y[12],Y[12],Y[12],Y[12],Y[11],Y[11],Y[11],Y[11],Y[11],Y[11],Y[11],Y[11],Y[10],Y[10],Y[10],Y[10],Y[10],Y[10],Y[10],Y[10],Y[9],Y[9],Y[9],Y[9],Y[9],Y[9],Y[9],Y[9],Y[8],Y[8],Y[8],Y[8],Y[8],Y[8],Y[8],Y[8],Y[7],Y[7],Y[7],Y[7],Y[7],Y[7],Y[7],Y[7],Y[6],Y[6],Y[6],Y[6],Y[6],Y[6],Y[6],Y[6],Y[5],Y[5],Y[5],Y[5],Y[5],Y[5],Y[5],Y[5],Y[4],Y[4],Y[4],Y[4],Y[4],Y[4],Y[4],Y[4],Y[3],Y[3],Y[3],Y[3],Y[3],Y[3],Y[3],Y[3],Y[2],Y[2],Y[2],Y[2],Y[2],Y[2],Y[2],Y[2],Y[1],Y[1],Y[1],Y[1],Y[1],Y[1],Y[1],Y[1],Y[0],Y[0],Y[0],Y[0],Y[0],Y[0],Y[0],Y[0]}
C {devices/lab_pin.sym} -40.0 -10.0 0 0 {name=l2 lab=WLEN}
C {devices/lab_pin.sym} -40.0 10.0 0 0 {name=l3 lab=WL[127:0]}
C {devices/lab_pin.sym} -40.0 30.0 0 0 {name=l4 lab=VDD}
C {devices/lab_pin.sym} -40.0 50.0 0 0 {name=l5 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=p6 lab=X[7]}
C {devices/ipin.sym} -900 -260 0 0 {name=p7 lab=X[6]}
C {devices/ipin.sym} -900 -220 0 0 {name=p8 lab=X[5]}
C {devices/ipin.sym} -900 -180 0 0 {name=p9 lab=X[4]}
C {devices/ipin.sym} -900 -140 0 0 {name=p10 lab=X[3]}
C {devices/ipin.sym} -900 -100 0 0 {name=p11 lab=X[2]}
C {devices/ipin.sym} -900 -60 0 0 {name=p12 lab=X[1]}
C {devices/ipin.sym} -900 -20 0 0 {name=p13 lab=X[0]}
C {devices/ipin.sym} -900 20 0 0 {name=p14 lab=Y[15]}
C {devices/ipin.sym} -900 60 0 0 {name=p15 lab=Y[14]}
C {devices/ipin.sym} -900 100 0 0 {name=p16 lab=Y[13]}
C {devices/ipin.sym} -900 140 0 0 {name=p17 lab=Y[12]}
C {devices/ipin.sym} -900 180 0 0 {name=p18 lab=Y[11]}
C {devices/ipin.sym} -900 220 0 0 {name=p19 lab=Y[10]}
C {devices/ipin.sym} -900 260 0 0 {name=p20 lab=Y[9]}
C {devices/ipin.sym} -900 300 0 0 {name=p21 lab=Y[8]}
C {devices/ipin.sym} -900 340 0 0 {name=p22 lab=Y[7]}
C {devices/ipin.sym} -900 380 0 0 {name=p23 lab=Y[6]}
C {devices/ipin.sym} -900 420 0 0 {name=p24 lab=Y[5]}
C {devices/ipin.sym} -900 460 0 0 {name=p25 lab=Y[4]}
C {devices/ipin.sym} -900 500 0 0 {name=p26 lab=Y[3]}
C {devices/ipin.sym} -900 540 0 0 {name=p27 lab=Y[2]}
C {devices/ipin.sym} -900 580 0 0 {name=p28 lab=Y[1]}
C {devices/ipin.sym} -900 620 0 0 {name=p29 lab=Y[0]}
C {devices/ipin.sym} -900 660 0 0 {name=p30 lab=WLEN}
C {devices/opin.sym} -900 700 0 0 {name=p31 lab=WL[127]}
C {devices/opin.sym} -900 740 0 0 {name=p32 lab=WL[126]}
C {devices/opin.sym} -900 780 0 0 {name=p33 lab=WL[125]}
C {devices/opin.sym} -900 820 0 0 {name=p34 lab=WL[124]}
C {devices/opin.sym} -900 860 0 0 {name=p35 lab=WL[123]}
C {devices/opin.sym} -900 900 0 0 {name=p36 lab=WL[122]}
C {devices/opin.sym} -900 940 0 0 {name=p37 lab=WL[121]}
C {devices/opin.sym} -900 980 0 0 {name=p38 lab=WL[120]}
C {devices/opin.sym} -900 1020 0 0 {name=p39 lab=WL[119]}
C {devices/opin.sym} -900 1060 0 0 {name=p40 lab=WL[118]}
C {devices/opin.sym} -900 1100 0 0 {name=p41 lab=WL[117]}
C {devices/opin.sym} -900 1140 0 0 {name=p42 lab=WL[116]}
C {devices/opin.sym} -900 1180 0 0 {name=p43 lab=WL[115]}
C {devices/opin.sym} -900 1220 0 0 {name=p44 lab=WL[114]}
C {devices/opin.sym} -900 1260 0 0 {name=p45 lab=WL[113]}
C {devices/opin.sym} -900 1300 0 0 {name=p46 lab=WL[112]}
C {devices/opin.sym} -900 1340 0 0 {name=p47 lab=WL[111]}
C {devices/opin.sym} -900 1380 0 0 {name=p48 lab=WL[110]}
C {devices/opin.sym} -900 1420 0 0 {name=p49 lab=WL[109]}
C {devices/opin.sym} -900 1460 0 0 {name=p50 lab=WL[108]}
C {devices/opin.sym} -900 1500 0 0 {name=p51 lab=WL[107]}
C {devices/opin.sym} -900 1540 0 0 {name=p52 lab=WL[106]}
C {devices/opin.sym} -900 1580 0 0 {name=p53 lab=WL[105]}
C {devices/opin.sym} -900 1620 0 0 {name=p54 lab=WL[104]}
C {devices/opin.sym} -900 1660 0 0 {name=p55 lab=WL[103]}
C {devices/opin.sym} -900 1700 0 0 {name=p56 lab=WL[102]}
C {devices/opin.sym} -900 1740 0 0 {name=p57 lab=WL[101]}
C {devices/opin.sym} -900 1780 0 0 {name=p58 lab=WL[100]}
C {devices/opin.sym} -900 1820 0 0 {name=p59 lab=WL[99]}
C {devices/opin.sym} -900 1860 0 0 {name=p60 lab=WL[98]}
C {devices/opin.sym} -900 1900 0 0 {name=p61 lab=WL[97]}
C {devices/opin.sym} -900 1940 0 0 {name=p62 lab=WL[96]}
C {devices/opin.sym} -900 1980 0 0 {name=p63 lab=WL[95]}
C {devices/opin.sym} -900 2020 0 0 {name=p64 lab=WL[94]}
C {devices/opin.sym} -900 2060 0 0 {name=p65 lab=WL[93]}
C {devices/opin.sym} -900 2100 0 0 {name=p66 lab=WL[92]}
C {devices/opin.sym} -900 2140 0 0 {name=p67 lab=WL[91]}
C {devices/opin.sym} -900 2180 0 0 {name=p68 lab=WL[90]}
C {devices/opin.sym} -900 2220 0 0 {name=p69 lab=WL[89]}
C {devices/opin.sym} -900 2260 0 0 {name=p70 lab=WL[88]}
C {devices/opin.sym} -900 2300 0 0 {name=p71 lab=WL[87]}
C {devices/opin.sym} -900 2340 0 0 {name=p72 lab=WL[86]}
C {devices/opin.sym} -900 2380 0 0 {name=p73 lab=WL[85]}
C {devices/opin.sym} -900 2420 0 0 {name=p74 lab=WL[84]}
C {devices/opin.sym} -900 2460 0 0 {name=p75 lab=WL[83]}
C {devices/opin.sym} -900 2500 0 0 {name=p76 lab=WL[82]}
C {devices/opin.sym} -900 2540 0 0 {name=p77 lab=WL[81]}
C {devices/opin.sym} -900 2580 0 0 {name=p78 lab=WL[80]}
C {devices/opin.sym} -900 2620 0 0 {name=p79 lab=WL[79]}
C {devices/opin.sym} -900 2660 0 0 {name=p80 lab=WL[78]}
C {devices/opin.sym} -900 2700 0 0 {name=p81 lab=WL[77]}
C {devices/opin.sym} -900 2740 0 0 {name=p82 lab=WL[76]}
C {devices/opin.sym} -900 2780 0 0 {name=p83 lab=WL[75]}
C {devices/opin.sym} -900 2820 0 0 {name=p84 lab=WL[74]}
C {devices/opin.sym} -900 2860 0 0 {name=p85 lab=WL[73]}
C {devices/opin.sym} -900 2900 0 0 {name=p86 lab=WL[72]}
C {devices/opin.sym} -900 2940 0 0 {name=p87 lab=WL[71]}
C {devices/opin.sym} -900 2980 0 0 {name=p88 lab=WL[70]}
C {devices/opin.sym} -900 3020 0 0 {name=p89 lab=WL[69]}
C {devices/opin.sym} -900 3060 0 0 {name=p90 lab=WL[68]}
C {devices/opin.sym} -900 3100 0 0 {name=p91 lab=WL[67]}
C {devices/opin.sym} -900 3140 0 0 {name=p92 lab=WL[66]}
C {devices/opin.sym} -900 3180 0 0 {name=p93 lab=WL[65]}
C {devices/opin.sym} -900 3220 0 0 {name=p94 lab=WL[64]}
C {devices/opin.sym} -900 3260 0 0 {name=p95 lab=WL[63]}
C {devices/opin.sym} -900 3300 0 0 {name=p96 lab=WL[62]}
C {devices/opin.sym} -900 3340 0 0 {name=p97 lab=WL[61]}
C {devices/opin.sym} -900 3380 0 0 {name=p98 lab=WL[60]}
C {devices/opin.sym} -900 3420 0 0 {name=p99 lab=WL[59]}
C {devices/opin.sym} -900 3460 0 0 {name=p100 lab=WL[58]}
C {devices/opin.sym} -900 3500 0 0 {name=p101 lab=WL[57]}
C {devices/opin.sym} -900 3540 0 0 {name=p102 lab=WL[56]}
C {devices/opin.sym} -900 3580 0 0 {name=p103 lab=WL[55]}
C {devices/opin.sym} -900 3620 0 0 {name=p104 lab=WL[54]}
C {devices/opin.sym} -900 3660 0 0 {name=p105 lab=WL[53]}
C {devices/opin.sym} -900 3700 0 0 {name=p106 lab=WL[52]}
C {devices/opin.sym} -900 3740 0 0 {name=p107 lab=WL[51]}
C {devices/opin.sym} -900 3780 0 0 {name=p108 lab=WL[50]}
C {devices/opin.sym} -900 3820 0 0 {name=p109 lab=WL[49]}
C {devices/opin.sym} -900 3860 0 0 {name=p110 lab=WL[48]}
C {devices/opin.sym} -900 3900 0 0 {name=p111 lab=WL[47]}
C {devices/opin.sym} -900 3940 0 0 {name=p112 lab=WL[46]}
C {devices/opin.sym} -900 3980 0 0 {name=p113 lab=WL[45]}
C {devices/opin.sym} -900 4020 0 0 {name=p114 lab=WL[44]}
C {devices/opin.sym} -900 4060 0 0 {name=p115 lab=WL[43]}
C {devices/opin.sym} -900 4100 0 0 {name=p116 lab=WL[42]}
C {devices/opin.sym} -900 4140 0 0 {name=p117 lab=WL[41]}
C {devices/opin.sym} -900 4180 0 0 {name=p118 lab=WL[40]}
C {devices/opin.sym} -900 4220 0 0 {name=p119 lab=WL[39]}
C {devices/opin.sym} -900 4260 0 0 {name=p120 lab=WL[38]}
C {devices/opin.sym} -900 4300 0 0 {name=p121 lab=WL[37]}
C {devices/opin.sym} -900 4340 0 0 {name=p122 lab=WL[36]}
C {devices/opin.sym} -900 4380 0 0 {name=p123 lab=WL[35]}
C {devices/opin.sym} -900 4420 0 0 {name=p124 lab=WL[34]}
C {devices/opin.sym} -900 4460 0 0 {name=p125 lab=WL[33]}
C {devices/opin.sym} -900 4500 0 0 {name=p126 lab=WL[32]}
C {devices/opin.sym} -900 4540 0 0 {name=p127 lab=WL[31]}
C {devices/opin.sym} -900 4580 0 0 {name=p128 lab=WL[30]}
C {devices/opin.sym} -900 4620 0 0 {name=p129 lab=WL[29]}
C {devices/opin.sym} -900 4660 0 0 {name=p130 lab=WL[28]}
C {devices/opin.sym} -900 4700 0 0 {name=p131 lab=WL[27]}
C {devices/opin.sym} -900 4740 0 0 {name=p132 lab=WL[26]}
C {devices/opin.sym} -900 4780 0 0 {name=p133 lab=WL[25]}
C {devices/opin.sym} -900 4820 0 0 {name=p134 lab=WL[24]}
C {devices/opin.sym} -900 4860 0 0 {name=p135 lab=WL[23]}
C {devices/opin.sym} -900 4900 0 0 {name=p136 lab=WL[22]}
C {devices/opin.sym} -900 4940 0 0 {name=p137 lab=WL[21]}
C {devices/opin.sym} -900 4980 0 0 {name=p138 lab=WL[20]}
C {devices/opin.sym} -900 5020 0 0 {name=p139 lab=WL[19]}
C {devices/opin.sym} -900 5060 0 0 {name=p140 lab=WL[18]}
C {devices/opin.sym} -900 5100 0 0 {name=p141 lab=WL[17]}
C {devices/opin.sym} -900 5140 0 0 {name=p142 lab=WL[16]}
C {devices/opin.sym} -900 5180 0 0 {name=p143 lab=WL[15]}
C {devices/opin.sym} -900 5220 0 0 {name=p144 lab=WL[14]}
C {devices/opin.sym} -900 5260 0 0 {name=p145 lab=WL[13]}
C {devices/opin.sym} -900 5300 0 0 {name=p146 lab=WL[12]}
C {devices/opin.sym} -900 5340 0 0 {name=p147 lab=WL[11]}
C {devices/opin.sym} -900 5380 0 0 {name=p148 lab=WL[10]}
C {devices/opin.sym} -900 5420 0 0 {name=p149 lab=WL[9]}
C {devices/opin.sym} -900 5460 0 0 {name=p150 lab=WL[8]}
C {devices/opin.sym} -900 5500 0 0 {name=p151 lab=WL[7]}
C {devices/opin.sym} -900 5540 0 0 {name=p152 lab=WL[6]}
C {devices/opin.sym} -900 5580 0 0 {name=p153 lab=WL[5]}
C {devices/opin.sym} -900 5620 0 0 {name=p154 lab=WL[4]}
C {devices/opin.sym} -900 5660 0 0 {name=p155 lab=WL[3]}
C {devices/opin.sym} -900 5700 0 0 {name=p156 lab=WL[2]}
C {devices/opin.sym} -900 5740 0 0 {name=p157 lab=WL[1]}
C {devices/opin.sym} -900 5780 0 0 {name=p158 lab=WL[0]}
C {devices/iopin.sym} -900 5820 0 0 {name=p159 lab=VDD}
C {devices/iopin.sym} -900 5860 0 0 {name=p160 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* 128 wordline drivers; row r = 8*j + k is driven by X[k] and Y[j]"}
