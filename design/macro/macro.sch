v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {latches/addr_latch.sym} 0 0 0 0 {name=XAL}
C {devices/lab_pin.sym} -40.0 -240.0 0 0 {name=l0 lab=CLK}
C {devices/lab_pin.sym} -40.0 -220.0 0 0 {name=l1 lab=A[7]}
C {devices/lab_pin.sym} -40.0 -200.0 0 0 {name=l2 lab=A[6]}
C {devices/lab_pin.sym} -40.0 -180.0 0 0 {name=l3 lab=A[5]}
C {devices/lab_pin.sym} -40.0 -160.0 0 0 {name=l4 lab=A[4]}
C {devices/lab_pin.sym} -40.0 -140.0 0 0 {name=l5 lab=A[3]}
C {devices/lab_pin.sym} -40.0 -120.0 0 0 {name=l6 lab=A[2]}
C {devices/lab_pin.sym} -40.0 -100.0 0 0 {name=l7 lab=A[1]}
C {devices/lab_pin.sym} -40.0 -80.0 0 0 {name=l8 lab=A[0]}
C {devices/lab_pin.sym} -40.0 -60.0 0 0 {name=l9 lab=CEN}
C {devices/lab_pin.sym} -40.0 -40.0 0 0 {name=l10 lab=GWEN}
C {devices/lab_pin.sym} -40.0 -20.0 0 0 {name=l11 lab=WEN}
C {devices/lab_pin.sym} -40.0 0.0 0 0 {name=l12 lab=AL[7]}
C {devices/lab_pin.sym} -40.0 20.0 0 0 {name=l13 lab=AL[6]}
C {devices/lab_pin.sym} -40.0 40.0 0 0 {name=l14 lab=AL[5]}
C {devices/lab_pin.sym} -40.0 60.0 0 0 {name=l15 lab=AL[4]}
C {devices/lab_pin.sym} -40.0 80.0 0 0 {name=l16 lab=AL[3]}
C {devices/lab_pin.sym} -40.0 100.0 0 0 {name=l17 lab=AL[2]}
C {devices/lab_pin.sym} -40.0 120.0 0 0 {name=l18 lab=AL[1]}
C {devices/lab_pin.sym} -40.0 140.0 0 0 {name=l19 lab=AL[0]}
C {devices/lab_pin.sym} -40.0 160.0 0 0 {name=l20 lab=CENL}
C {devices/lab_pin.sym} -40.0 180.0 0 0 {name=l21 lab=GWENL}
C {devices/lab_pin.sym} -40.0 200.0 0 0 {name=l22 lab=WENL}
C {devices/lab_pin.sym} -40.0 220.0 0 0 {name=l23 lab=VDD}
C {devices/lab_pin.sym} -40.0 240.0 0 0 {name=l24 lab=VSS}
C {control/control.sym} 400 0 0 0 {name=XCTL}
C {devices/lab_pin.sym} 360.0 -140.0 0 0 {name=l25 lab=CLK}
C {devices/lab_pin.sym} 360.0 -120.0 0 0 {name=l26 lab=CENL}
C {devices/lab_pin.sym} 360.0 -100.0 0 0 {name=l27 lab=GWENL}
C {devices/lab_pin.sym} 360.0 -80.0 0 0 {name=l28 lab=WENL}
C {devices/lab_pin.sym} 360.0 -60.0 0 0 {name=l29 lab=AL[0]}
C {devices/lab_pin.sym} 360.0 -40.0 0 0 {name=l30 lab=PRE_B}
C {devices/lab_pin.sym} 360.0 -20.0 0 0 {name=l31 lab=WLEN}
C {devices/lab_pin.sym} 360.0 0.0 0 0 {name=l32 lab=SAE}
C {devices/lab_pin.sym} 360.0 20.0 0 0 {name=l33 lab=WE}
C {devices/lab_pin.sym} 360.0 40.0 0 0 {name=l34 lab=SEL0}
C {devices/lab_pin.sym} 360.0 60.0 0 0 {name=l35 lab=SEL0B}
C {devices/lab_pin.sym} 360.0 80.0 0 0 {name=l36 lab=SEL1}
C {devices/lab_pin.sym} 360.0 100.0 0 0 {name=l37 lab=SEL1B}
C {devices/lab_pin.sym} 360.0 120.0 0 0 {name=l38 lab=VDD}
C {devices/lab_pin.sym} 360.0 140.0 0 0 {name=l39 lab=VSS}
C {decoder/row_decoder.sym} 800 0 0 0 {name=XDEC}
C {devices/lab_pin.sym} 760.0 -1370.0 0 0 {name=l40 lab=AL[7]}
C {devices/lab_pin.sym} 760.0 -1350.0 0 0 {name=l41 lab=AL[6]}
C {devices/lab_pin.sym} 760.0 -1330.0 0 0 {name=l42 lab=AL[5]}
C {devices/lab_pin.sym} 760.0 -1310.0 0 0 {name=l43 lab=AL[4]}
C {devices/lab_pin.sym} 760.0 -1290.0 0 0 {name=l44 lab=AL[3]}
C {devices/lab_pin.sym} 760.0 -1270.0 0 0 {name=l45 lab=AL[2]}
C {devices/lab_pin.sym} 760.0 -1250.0 0 0 {name=l46 lab=AL[1]}
C {devices/lab_pin.sym} 760.0 -1230.0 0 0 {name=l47 lab=WLEN}
C {devices/lab_pin.sym} 760.0 -1210.0 0 0 {name=l48 lab=WL[127]}
C {devices/lab_pin.sym} 760.0 -1190.0 0 0 {name=l49 lab=WL[126]}
C {devices/lab_pin.sym} 760.0 -1170.0 0 0 {name=l50 lab=WL[125]}
C {devices/lab_pin.sym} 760.0 -1150.0 0 0 {name=l51 lab=WL[124]}
C {devices/lab_pin.sym} 760.0 -1130.0 0 0 {name=l52 lab=WL[123]}
C {devices/lab_pin.sym} 760.0 -1110.0 0 0 {name=l53 lab=WL[122]}
C {devices/lab_pin.sym} 760.0 -1090.0 0 0 {name=l54 lab=WL[121]}
C {devices/lab_pin.sym} 760.0 -1070.0 0 0 {name=l55 lab=WL[120]}
C {devices/lab_pin.sym} 760.0 -1050.0 0 0 {name=l56 lab=WL[119]}
C {devices/lab_pin.sym} 760.0 -1030.0 0 0 {name=l57 lab=WL[118]}
C {devices/lab_pin.sym} 760.0 -1010.0 0 0 {name=l58 lab=WL[117]}
C {devices/lab_pin.sym} 760.0 -990.0 0 0 {name=l59 lab=WL[116]}
C {devices/lab_pin.sym} 760.0 -970.0 0 0 {name=l60 lab=WL[115]}
C {devices/lab_pin.sym} 760.0 -950.0 0 0 {name=l61 lab=WL[114]}
C {devices/lab_pin.sym} 760.0 -930.0 0 0 {name=l62 lab=WL[113]}
C {devices/lab_pin.sym} 760.0 -910.0 0 0 {name=l63 lab=WL[112]}
C {devices/lab_pin.sym} 760.0 -890.0 0 0 {name=l64 lab=WL[111]}
C {devices/lab_pin.sym} 760.0 -870.0 0 0 {name=l65 lab=WL[110]}
C {devices/lab_pin.sym} 760.0 -850.0 0 0 {name=l66 lab=WL[109]}
C {devices/lab_pin.sym} 760.0 -830.0 0 0 {name=l67 lab=WL[108]}
C {devices/lab_pin.sym} 760.0 -810.0 0 0 {name=l68 lab=WL[107]}
C {devices/lab_pin.sym} 760.0 -790.0 0 0 {name=l69 lab=WL[106]}
C {devices/lab_pin.sym} 760.0 -770.0 0 0 {name=l70 lab=WL[105]}
C {devices/lab_pin.sym} 760.0 -750.0 0 0 {name=l71 lab=WL[104]}
C {devices/lab_pin.sym} 760.0 -730.0 0 0 {name=l72 lab=WL[103]}
C {devices/lab_pin.sym} 760.0 -710.0 0 0 {name=l73 lab=WL[102]}
C {devices/lab_pin.sym} 760.0 -690.0 0 0 {name=l74 lab=WL[101]}
C {devices/lab_pin.sym} 760.0 -670.0 0 0 {name=l75 lab=WL[100]}
C {devices/lab_pin.sym} 760.0 -650.0 0 0 {name=l76 lab=WL[99]}
C {devices/lab_pin.sym} 760.0 -630.0 0 0 {name=l77 lab=WL[98]}
C {devices/lab_pin.sym} 760.0 -610.0 0 0 {name=l78 lab=WL[97]}
C {devices/lab_pin.sym} 760.0 -590.0 0 0 {name=l79 lab=WL[96]}
C {devices/lab_pin.sym} 760.0 -570.0 0 0 {name=l80 lab=WL[95]}
C {devices/lab_pin.sym} 760.0 -550.0 0 0 {name=l81 lab=WL[94]}
C {devices/lab_pin.sym} 760.0 -530.0 0 0 {name=l82 lab=WL[93]}
C {devices/lab_pin.sym} 760.0 -510.0 0 0 {name=l83 lab=WL[92]}
C {devices/lab_pin.sym} 760.0 -490.0 0 0 {name=l84 lab=WL[91]}
C {devices/lab_pin.sym} 760.0 -470.0 0 0 {name=l85 lab=WL[90]}
C {devices/lab_pin.sym} 760.0 -450.0 0 0 {name=l86 lab=WL[89]}
C {devices/lab_pin.sym} 760.0 -430.0 0 0 {name=l87 lab=WL[88]}
C {devices/lab_pin.sym} 760.0 -410.0 0 0 {name=l88 lab=WL[87]}
C {devices/lab_pin.sym} 760.0 -390.0 0 0 {name=l89 lab=WL[86]}
C {devices/lab_pin.sym} 760.0 -370.0 0 0 {name=l90 lab=WL[85]}
C {devices/lab_pin.sym} 760.0 -350.0 0 0 {name=l91 lab=WL[84]}
C {devices/lab_pin.sym} 760.0 -330.0 0 0 {name=l92 lab=WL[83]}
C {devices/lab_pin.sym} 760.0 -310.0 0 0 {name=l93 lab=WL[82]}
C {devices/lab_pin.sym} 760.0 -290.0 0 0 {name=l94 lab=WL[81]}
C {devices/lab_pin.sym} 760.0 -270.0 0 0 {name=l95 lab=WL[80]}
C {devices/lab_pin.sym} 760.0 -250.0 0 0 {name=l96 lab=WL[79]}
C {devices/lab_pin.sym} 760.0 -230.0 0 0 {name=l97 lab=WL[78]}
C {devices/lab_pin.sym} 760.0 -210.0 0 0 {name=l98 lab=WL[77]}
C {devices/lab_pin.sym} 760.0 -190.0 0 0 {name=l99 lab=WL[76]}
C {devices/lab_pin.sym} 760.0 -170.0 0 0 {name=l100 lab=WL[75]}
C {devices/lab_pin.sym} 760.0 -150.0 0 0 {name=l101 lab=WL[74]}
C {devices/lab_pin.sym} 760.0 -130.0 0 0 {name=l102 lab=WL[73]}
C {devices/lab_pin.sym} 760.0 -110.0 0 0 {name=l103 lab=WL[72]}
C {devices/lab_pin.sym} 760.0 -90.0 0 0 {name=l104 lab=WL[71]}
C {devices/lab_pin.sym} 760.0 -70.0 0 0 {name=l105 lab=WL[70]}
C {devices/lab_pin.sym} 760.0 -50.0 0 0 {name=l106 lab=WL[69]}
C {devices/lab_pin.sym} 760.0 -30.0 0 0 {name=l107 lab=WL[68]}
C {devices/lab_pin.sym} 760.0 -10.0 0 0 {name=l108 lab=WL[67]}
C {devices/lab_pin.sym} 760.0 10.0 0 0 {name=l109 lab=WL[66]}
C {devices/lab_pin.sym} 760.0 30.0 0 0 {name=l110 lab=WL[65]}
C {devices/lab_pin.sym} 760.0 50.0 0 0 {name=l111 lab=WL[64]}
C {devices/lab_pin.sym} 760.0 70.0 0 0 {name=l112 lab=WL[63]}
C {devices/lab_pin.sym} 760.0 90.0 0 0 {name=l113 lab=WL[62]}
C {devices/lab_pin.sym} 760.0 110.0 0 0 {name=l114 lab=WL[61]}
C {devices/lab_pin.sym} 760.0 130.0 0 0 {name=l115 lab=WL[60]}
C {devices/lab_pin.sym} 760.0 150.0 0 0 {name=l116 lab=WL[59]}
C {devices/lab_pin.sym} 760.0 170.0 0 0 {name=l117 lab=WL[58]}
C {devices/lab_pin.sym} 760.0 190.0 0 0 {name=l118 lab=WL[57]}
C {devices/lab_pin.sym} 760.0 210.0 0 0 {name=l119 lab=WL[56]}
C {devices/lab_pin.sym} 760.0 230.0 0 0 {name=l120 lab=WL[55]}
C {devices/lab_pin.sym} 760.0 250.0 0 0 {name=l121 lab=WL[54]}
C {devices/lab_pin.sym} 760.0 270.0 0 0 {name=l122 lab=WL[53]}
C {devices/lab_pin.sym} 760.0 290.0 0 0 {name=l123 lab=WL[52]}
C {devices/lab_pin.sym} 760.0 310.0 0 0 {name=l124 lab=WL[51]}
C {devices/lab_pin.sym} 760.0 330.0 0 0 {name=l125 lab=WL[50]}
C {devices/lab_pin.sym} 760.0 350.0 0 0 {name=l126 lab=WL[49]}
C {devices/lab_pin.sym} 760.0 370.0 0 0 {name=l127 lab=WL[48]}
C {devices/lab_pin.sym} 760.0 390.0 0 0 {name=l128 lab=WL[47]}
C {devices/lab_pin.sym} 760.0 410.0 0 0 {name=l129 lab=WL[46]}
C {devices/lab_pin.sym} 760.0 430.0 0 0 {name=l130 lab=WL[45]}
C {devices/lab_pin.sym} 760.0 450.0 0 0 {name=l131 lab=WL[44]}
C {devices/lab_pin.sym} 760.0 470.0 0 0 {name=l132 lab=WL[43]}
C {devices/lab_pin.sym} 760.0 490.0 0 0 {name=l133 lab=WL[42]}
C {devices/lab_pin.sym} 760.0 510.0 0 0 {name=l134 lab=WL[41]}
C {devices/lab_pin.sym} 760.0 530.0 0 0 {name=l135 lab=WL[40]}
C {devices/lab_pin.sym} 760.0 550.0 0 0 {name=l136 lab=WL[39]}
C {devices/lab_pin.sym} 760.0 570.0 0 0 {name=l137 lab=WL[38]}
C {devices/lab_pin.sym} 760.0 590.0 0 0 {name=l138 lab=WL[37]}
C {devices/lab_pin.sym} 760.0 610.0 0 0 {name=l139 lab=WL[36]}
C {devices/lab_pin.sym} 760.0 630.0 0 0 {name=l140 lab=WL[35]}
C {devices/lab_pin.sym} 760.0 650.0 0 0 {name=l141 lab=WL[34]}
C {devices/lab_pin.sym} 760.0 670.0 0 0 {name=l142 lab=WL[33]}
C {devices/lab_pin.sym} 760.0 690.0 0 0 {name=l143 lab=WL[32]}
C {devices/lab_pin.sym} 760.0 710.0 0 0 {name=l144 lab=WL[31]}
C {devices/lab_pin.sym} 760.0 730.0 0 0 {name=l145 lab=WL[30]}
C {devices/lab_pin.sym} 760.0 750.0 0 0 {name=l146 lab=WL[29]}
C {devices/lab_pin.sym} 760.0 770.0 0 0 {name=l147 lab=WL[28]}
C {devices/lab_pin.sym} 760.0 790.0 0 0 {name=l148 lab=WL[27]}
C {devices/lab_pin.sym} 760.0 810.0 0 0 {name=l149 lab=WL[26]}
C {devices/lab_pin.sym} 760.0 830.0 0 0 {name=l150 lab=WL[25]}
C {devices/lab_pin.sym} 760.0 850.0 0 0 {name=l151 lab=WL[24]}
C {devices/lab_pin.sym} 760.0 870.0 0 0 {name=l152 lab=WL[23]}
C {devices/lab_pin.sym} 760.0 890.0 0 0 {name=l153 lab=WL[22]}
C {devices/lab_pin.sym} 760.0 910.0 0 0 {name=l154 lab=WL[21]}
C {devices/lab_pin.sym} 760.0 930.0 0 0 {name=l155 lab=WL[20]}
C {devices/lab_pin.sym} 760.0 950.0 0 0 {name=l156 lab=WL[19]}
C {devices/lab_pin.sym} 760.0 970.0 0 0 {name=l157 lab=WL[18]}
C {devices/lab_pin.sym} 760.0 990.0 0 0 {name=l158 lab=WL[17]}
C {devices/lab_pin.sym} 760.0 1010.0 0 0 {name=l159 lab=WL[16]}
C {devices/lab_pin.sym} 760.0 1030.0 0 0 {name=l160 lab=WL[15]}
C {devices/lab_pin.sym} 760.0 1050.0 0 0 {name=l161 lab=WL[14]}
C {devices/lab_pin.sym} 760.0 1070.0 0 0 {name=l162 lab=WL[13]}
C {devices/lab_pin.sym} 760.0 1090.0 0 0 {name=l163 lab=WL[12]}
C {devices/lab_pin.sym} 760.0 1110.0 0 0 {name=l164 lab=WL[11]}
C {devices/lab_pin.sym} 760.0 1130.0 0 0 {name=l165 lab=WL[10]}
C {devices/lab_pin.sym} 760.0 1150.0 0 0 {name=l166 lab=WL[9]}
C {devices/lab_pin.sym} 760.0 1170.0 0 0 {name=l167 lab=WL[8]}
C {devices/lab_pin.sym} 760.0 1190.0 0 0 {name=l168 lab=WL[7]}
C {devices/lab_pin.sym} 760.0 1210.0 0 0 {name=l169 lab=WL[6]}
C {devices/lab_pin.sym} 760.0 1230.0 0 0 {name=l170 lab=WL[5]}
C {devices/lab_pin.sym} 760.0 1250.0 0 0 {name=l171 lab=WL[4]}
C {devices/lab_pin.sym} 760.0 1270.0 0 0 {name=l172 lab=WL[3]}
C {devices/lab_pin.sym} 760.0 1290.0 0 0 {name=l173 lab=WL[2]}
C {devices/lab_pin.sym} 760.0 1310.0 0 0 {name=l174 lab=WL[1]}
C {devices/lab_pin.sym} 760.0 1330.0 0 0 {name=l175 lab=WL[0]}
C {devices/lab_pin.sym} 760.0 1350.0 0 0 {name=l176 lab=VDD}
C {devices/lab_pin.sym} 760.0 1370.0 0 0 {name=l177 lab=VSS}
C {latches/data_latch.sym} 1200 0 0 0 {name=XDL}
C {devices/lab_pin.sym} 1160.0 -660.0 0 0 {name=l178 lab=CLK}
C {devices/lab_pin.sym} 1160.0 -640.0 0 0 {name=l179 lab=D[31]}
C {devices/lab_pin.sym} 1160.0 -620.0 0 0 {name=l180 lab=D[30]}
C {devices/lab_pin.sym} 1160.0 -600.0 0 0 {name=l181 lab=D[29]}
C {devices/lab_pin.sym} 1160.0 -580.0 0 0 {name=l182 lab=D[28]}
C {devices/lab_pin.sym} 1160.0 -560.0 0 0 {name=l183 lab=D[27]}
C {devices/lab_pin.sym} 1160.0 -540.0 0 0 {name=l184 lab=D[26]}
C {devices/lab_pin.sym} 1160.0 -520.0 0 0 {name=l185 lab=D[25]}
C {devices/lab_pin.sym} 1160.0 -500.0 0 0 {name=l186 lab=D[24]}
C {devices/lab_pin.sym} 1160.0 -480.0 0 0 {name=l187 lab=D[23]}
C {devices/lab_pin.sym} 1160.0 -460.0 0 0 {name=l188 lab=D[22]}
C {devices/lab_pin.sym} 1160.0 -440.0 0 0 {name=l189 lab=D[21]}
C {devices/lab_pin.sym} 1160.0 -420.0 0 0 {name=l190 lab=D[20]}
C {devices/lab_pin.sym} 1160.0 -400.0 0 0 {name=l191 lab=D[19]}
C {devices/lab_pin.sym} 1160.0 -380.0 0 0 {name=l192 lab=D[18]}
C {devices/lab_pin.sym} 1160.0 -360.0 0 0 {name=l193 lab=D[17]}
C {devices/lab_pin.sym} 1160.0 -340.0 0 0 {name=l194 lab=D[16]}
C {devices/lab_pin.sym} 1160.0 -320.0 0 0 {name=l195 lab=D[15]}
C {devices/lab_pin.sym} 1160.0 -300.0 0 0 {name=l196 lab=D[14]}
C {devices/lab_pin.sym} 1160.0 -280.0 0 0 {name=l197 lab=D[13]}
C {devices/lab_pin.sym} 1160.0 -260.0 0 0 {name=l198 lab=D[12]}
C {devices/lab_pin.sym} 1160.0 -240.0 0 0 {name=l199 lab=D[11]}
C {devices/lab_pin.sym} 1160.0 -220.0 0 0 {name=l200 lab=D[10]}
C {devices/lab_pin.sym} 1160.0 -200.0 0 0 {name=l201 lab=D[9]}
C {devices/lab_pin.sym} 1160.0 -180.0 0 0 {name=l202 lab=D[8]}
C {devices/lab_pin.sym} 1160.0 -160.0 0 0 {name=l203 lab=D[7]}
C {devices/lab_pin.sym} 1160.0 -140.0 0 0 {name=l204 lab=D[6]}
C {devices/lab_pin.sym} 1160.0 -120.0 0 0 {name=l205 lab=D[5]}
C {devices/lab_pin.sym} 1160.0 -100.0 0 0 {name=l206 lab=D[4]}
C {devices/lab_pin.sym} 1160.0 -80.0 0 0 {name=l207 lab=D[3]}
C {devices/lab_pin.sym} 1160.0 -60.0 0 0 {name=l208 lab=D[2]}
C {devices/lab_pin.sym} 1160.0 -40.0 0 0 {name=l209 lab=D[1]}
C {devices/lab_pin.sym} 1160.0 -20.0 0 0 {name=l210 lab=D[0]}
C {devices/lab_pin.sym} 1160.0 0.0 0 0 {name=l211 lab=DL[31]}
C {devices/lab_pin.sym} 1160.0 20.0 0 0 {name=l212 lab=DL[30]}
C {devices/lab_pin.sym} 1160.0 40.0 0 0 {name=l213 lab=DL[29]}
C {devices/lab_pin.sym} 1160.0 60.0 0 0 {name=l214 lab=DL[28]}
C {devices/lab_pin.sym} 1160.0 80.0 0 0 {name=l215 lab=DL[27]}
C {devices/lab_pin.sym} 1160.0 100.0 0 0 {name=l216 lab=DL[26]}
C {devices/lab_pin.sym} 1160.0 120.0 0 0 {name=l217 lab=DL[25]}
C {devices/lab_pin.sym} 1160.0 140.0 0 0 {name=l218 lab=DL[24]}
C {devices/lab_pin.sym} 1160.0 160.0 0 0 {name=l219 lab=DL[23]}
C {devices/lab_pin.sym} 1160.0 180.0 0 0 {name=l220 lab=DL[22]}
C {devices/lab_pin.sym} 1160.0 200.0 0 0 {name=l221 lab=DL[21]}
C {devices/lab_pin.sym} 1160.0 220.0 0 0 {name=l222 lab=DL[20]}
C {devices/lab_pin.sym} 1160.0 240.0 0 0 {name=l223 lab=DL[19]}
C {devices/lab_pin.sym} 1160.0 260.0 0 0 {name=l224 lab=DL[18]}
C {devices/lab_pin.sym} 1160.0 280.0 0 0 {name=l225 lab=DL[17]}
C {devices/lab_pin.sym} 1160.0 300.0 0 0 {name=l226 lab=DL[16]}
C {devices/lab_pin.sym} 1160.0 320.0 0 0 {name=l227 lab=DL[15]}
C {devices/lab_pin.sym} 1160.0 340.0 0 0 {name=l228 lab=DL[14]}
C {devices/lab_pin.sym} 1160.0 360.0 0 0 {name=l229 lab=DL[13]}
C {devices/lab_pin.sym} 1160.0 380.0 0 0 {name=l230 lab=DL[12]}
C {devices/lab_pin.sym} 1160.0 400.0 0 0 {name=l231 lab=DL[11]}
C {devices/lab_pin.sym} 1160.0 420.0 0 0 {name=l232 lab=DL[10]}
C {devices/lab_pin.sym} 1160.0 440.0 0 0 {name=l233 lab=DL[9]}
C {devices/lab_pin.sym} 1160.0 460.0 0 0 {name=l234 lab=DL[8]}
C {devices/lab_pin.sym} 1160.0 480.0 0 0 {name=l235 lab=DL[7]}
C {devices/lab_pin.sym} 1160.0 500.0 0 0 {name=l236 lab=DL[6]}
C {devices/lab_pin.sym} 1160.0 520.0 0 0 {name=l237 lab=DL[5]}
C {devices/lab_pin.sym} 1160.0 540.0 0 0 {name=l238 lab=DL[4]}
C {devices/lab_pin.sym} 1160.0 560.0 0 0 {name=l239 lab=DL[3]}
C {devices/lab_pin.sym} 1160.0 580.0 0 0 {name=l240 lab=DL[2]}
C {devices/lab_pin.sym} 1160.0 600.0 0 0 {name=l241 lab=DL[1]}
C {devices/lab_pin.sym} 1160.0 620.0 0 0 {name=l242 lab=DL[0]}
C {devices/lab_pin.sym} 1160.0 640.0 0 0 {name=l243 lab=VDD}
C {devices/lab_pin.sym} 1160.0 660.0 0 0 {name=l244 lab=VSS}
C {macro/bit_slice.sym} 0 2880 0 0 {name=XS[31:0]}
C {devices/lab_pin.sym} -40.0 1490.0 0 0 {name=l245 lab=PRE_B}
C {devices/lab_pin.sym} -40.0 1510.0 0 0 {name=l246 lab=SEL0}
C {devices/lab_pin.sym} -40.0 1530.0 0 0 {name=l247 lab=SEL0B}
C {devices/lab_pin.sym} -40.0 1550.0 0 0 {name=l248 lab=SEL1}
C {devices/lab_pin.sym} -40.0 1570.0 0 0 {name=l249 lab=SEL1B}
C {devices/lab_pin.sym} -40.0 1590.0 0 0 {name=l250 lab=SAE}
C {devices/lab_pin.sym} -40.0 1610.0 0 0 {name=l251 lab=WE}
C {devices/lab_pin.sym} -40.0 1630.0 0 0 {name=l252 lab=DL[31:0]}
C {devices/lab_pin.sym} -40.0 1650.0 0 0 {name=l253 lab=WL[127]}
C {devices/lab_pin.sym} -40.0 1670.0 0 0 {name=l254 lab=WL[126]}
C {devices/lab_pin.sym} -40.0 1690.0 0 0 {name=l255 lab=WL[125]}
C {devices/lab_pin.sym} -40.0 1710.0 0 0 {name=l256 lab=WL[124]}
C {devices/lab_pin.sym} -40.0 1730.0 0 0 {name=l257 lab=WL[123]}
C {devices/lab_pin.sym} -40.0 1750.0 0 0 {name=l258 lab=WL[122]}
C {devices/lab_pin.sym} -40.0 1770.0 0 0 {name=l259 lab=WL[121]}
C {devices/lab_pin.sym} -40.0 1790.0 0 0 {name=l260 lab=WL[120]}
C {devices/lab_pin.sym} -40.0 1810.0 0 0 {name=l261 lab=WL[119]}
C {devices/lab_pin.sym} -40.0 1830.0 0 0 {name=l262 lab=WL[118]}
C {devices/lab_pin.sym} -40.0 1850.0 0 0 {name=l263 lab=WL[117]}
C {devices/lab_pin.sym} -40.0 1870.0 0 0 {name=l264 lab=WL[116]}
C {devices/lab_pin.sym} -40.0 1890.0 0 0 {name=l265 lab=WL[115]}
C {devices/lab_pin.sym} -40.0 1910.0 0 0 {name=l266 lab=WL[114]}
C {devices/lab_pin.sym} -40.0 1930.0 0 0 {name=l267 lab=WL[113]}
C {devices/lab_pin.sym} -40.0 1950.0 0 0 {name=l268 lab=WL[112]}
C {devices/lab_pin.sym} -40.0 1970.0 0 0 {name=l269 lab=WL[111]}
C {devices/lab_pin.sym} -40.0 1990.0 0 0 {name=l270 lab=WL[110]}
C {devices/lab_pin.sym} -40.0 2010.0 0 0 {name=l271 lab=WL[109]}
C {devices/lab_pin.sym} -40.0 2030.0 0 0 {name=l272 lab=WL[108]}
C {devices/lab_pin.sym} -40.0 2050.0 0 0 {name=l273 lab=WL[107]}
C {devices/lab_pin.sym} -40.0 2070.0 0 0 {name=l274 lab=WL[106]}
C {devices/lab_pin.sym} -40.0 2090.0 0 0 {name=l275 lab=WL[105]}
C {devices/lab_pin.sym} -40.0 2110.0 0 0 {name=l276 lab=WL[104]}
C {devices/lab_pin.sym} -40.0 2130.0 0 0 {name=l277 lab=WL[103]}
C {devices/lab_pin.sym} -40.0 2150.0 0 0 {name=l278 lab=WL[102]}
C {devices/lab_pin.sym} -40.0 2170.0 0 0 {name=l279 lab=WL[101]}
C {devices/lab_pin.sym} -40.0 2190.0 0 0 {name=l280 lab=WL[100]}
C {devices/lab_pin.sym} -40.0 2210.0 0 0 {name=l281 lab=WL[99]}
C {devices/lab_pin.sym} -40.0 2230.0 0 0 {name=l282 lab=WL[98]}
C {devices/lab_pin.sym} -40.0 2250.0 0 0 {name=l283 lab=WL[97]}
C {devices/lab_pin.sym} -40.0 2270.0 0 0 {name=l284 lab=WL[96]}
C {devices/lab_pin.sym} -40.0 2290.0 0 0 {name=l285 lab=WL[95]}
C {devices/lab_pin.sym} -40.0 2310.0 0 0 {name=l286 lab=WL[94]}
C {devices/lab_pin.sym} -40.0 2330.0 0 0 {name=l287 lab=WL[93]}
C {devices/lab_pin.sym} -40.0 2350.0 0 0 {name=l288 lab=WL[92]}
C {devices/lab_pin.sym} -40.0 2370.0 0 0 {name=l289 lab=WL[91]}
C {devices/lab_pin.sym} -40.0 2390.0 0 0 {name=l290 lab=WL[90]}
C {devices/lab_pin.sym} -40.0 2410.0 0 0 {name=l291 lab=WL[89]}
C {devices/lab_pin.sym} -40.0 2430.0 0 0 {name=l292 lab=WL[88]}
C {devices/lab_pin.sym} -40.0 2450.0 0 0 {name=l293 lab=WL[87]}
C {devices/lab_pin.sym} -40.0 2470.0 0 0 {name=l294 lab=WL[86]}
C {devices/lab_pin.sym} -40.0 2490.0 0 0 {name=l295 lab=WL[85]}
C {devices/lab_pin.sym} -40.0 2510.0 0 0 {name=l296 lab=WL[84]}
C {devices/lab_pin.sym} -40.0 2530.0 0 0 {name=l297 lab=WL[83]}
C {devices/lab_pin.sym} -40.0 2550.0 0 0 {name=l298 lab=WL[82]}
C {devices/lab_pin.sym} -40.0 2570.0 0 0 {name=l299 lab=WL[81]}
C {devices/lab_pin.sym} -40.0 2590.0 0 0 {name=l300 lab=WL[80]}
C {devices/lab_pin.sym} -40.0 2610.0 0 0 {name=l301 lab=WL[79]}
C {devices/lab_pin.sym} -40.0 2630.0 0 0 {name=l302 lab=WL[78]}
C {devices/lab_pin.sym} -40.0 2650.0 0 0 {name=l303 lab=WL[77]}
C {devices/lab_pin.sym} -40.0 2670.0 0 0 {name=l304 lab=WL[76]}
C {devices/lab_pin.sym} -40.0 2690.0 0 0 {name=l305 lab=WL[75]}
C {devices/lab_pin.sym} -40.0 2710.0 0 0 {name=l306 lab=WL[74]}
C {devices/lab_pin.sym} -40.0 2730.0 0 0 {name=l307 lab=WL[73]}
C {devices/lab_pin.sym} -40.0 2750.0 0 0 {name=l308 lab=WL[72]}
C {devices/lab_pin.sym} -40.0 2770.0 0 0 {name=l309 lab=WL[71]}
C {devices/lab_pin.sym} -40.0 2790.0 0 0 {name=l310 lab=WL[70]}
C {devices/lab_pin.sym} -40.0 2810.0 0 0 {name=l311 lab=WL[69]}
C {devices/lab_pin.sym} -40.0 2830.0 0 0 {name=l312 lab=WL[68]}
C {devices/lab_pin.sym} -40.0 2850.0 0 0 {name=l313 lab=WL[67]}
C {devices/lab_pin.sym} -40.0 2870.0 0 0 {name=l314 lab=WL[66]}
C {devices/lab_pin.sym} -40.0 2890.0 0 0 {name=l315 lab=WL[65]}
C {devices/lab_pin.sym} -40.0 2910.0 0 0 {name=l316 lab=WL[64]}
C {devices/lab_pin.sym} -40.0 2930.0 0 0 {name=l317 lab=WL[63]}
C {devices/lab_pin.sym} -40.0 2950.0 0 0 {name=l318 lab=WL[62]}
C {devices/lab_pin.sym} -40.0 2970.0 0 0 {name=l319 lab=WL[61]}
C {devices/lab_pin.sym} -40.0 2990.0 0 0 {name=l320 lab=WL[60]}
C {devices/lab_pin.sym} -40.0 3010.0 0 0 {name=l321 lab=WL[59]}
C {devices/lab_pin.sym} -40.0 3030.0 0 0 {name=l322 lab=WL[58]}
C {devices/lab_pin.sym} -40.0 3050.0 0 0 {name=l323 lab=WL[57]}
C {devices/lab_pin.sym} -40.0 3070.0 0 0 {name=l324 lab=WL[56]}
C {devices/lab_pin.sym} -40.0 3090.0 0 0 {name=l325 lab=WL[55]}
C {devices/lab_pin.sym} -40.0 3110.0 0 0 {name=l326 lab=WL[54]}
C {devices/lab_pin.sym} -40.0 3130.0 0 0 {name=l327 lab=WL[53]}
C {devices/lab_pin.sym} -40.0 3150.0 0 0 {name=l328 lab=WL[52]}
C {devices/lab_pin.sym} -40.0 3170.0 0 0 {name=l329 lab=WL[51]}
C {devices/lab_pin.sym} -40.0 3190.0 0 0 {name=l330 lab=WL[50]}
C {devices/lab_pin.sym} -40.0 3210.0 0 0 {name=l331 lab=WL[49]}
C {devices/lab_pin.sym} -40.0 3230.0 0 0 {name=l332 lab=WL[48]}
C {devices/lab_pin.sym} -40.0 3250.0 0 0 {name=l333 lab=WL[47]}
C {devices/lab_pin.sym} -40.0 3270.0 0 0 {name=l334 lab=WL[46]}
C {devices/lab_pin.sym} -40.0 3290.0 0 0 {name=l335 lab=WL[45]}
C {devices/lab_pin.sym} -40.0 3310.0 0 0 {name=l336 lab=WL[44]}
C {devices/lab_pin.sym} -40.0 3330.0 0 0 {name=l337 lab=WL[43]}
C {devices/lab_pin.sym} -40.0 3350.0 0 0 {name=l338 lab=WL[42]}
C {devices/lab_pin.sym} -40.0 3370.0 0 0 {name=l339 lab=WL[41]}
C {devices/lab_pin.sym} -40.0 3390.0 0 0 {name=l340 lab=WL[40]}
C {devices/lab_pin.sym} -40.0 3410.0 0 0 {name=l341 lab=WL[39]}
C {devices/lab_pin.sym} -40.0 3430.0 0 0 {name=l342 lab=WL[38]}
C {devices/lab_pin.sym} -40.0 3450.0 0 0 {name=l343 lab=WL[37]}
C {devices/lab_pin.sym} -40.0 3470.0 0 0 {name=l344 lab=WL[36]}
C {devices/lab_pin.sym} -40.0 3490.0 0 0 {name=l345 lab=WL[35]}
C {devices/lab_pin.sym} -40.0 3510.0 0 0 {name=l346 lab=WL[34]}
C {devices/lab_pin.sym} -40.0 3530.0 0 0 {name=l347 lab=WL[33]}
C {devices/lab_pin.sym} -40.0 3550.0 0 0 {name=l348 lab=WL[32]}
C {devices/lab_pin.sym} -40.0 3570.0 0 0 {name=l349 lab=WL[31]}
C {devices/lab_pin.sym} -40.0 3590.0 0 0 {name=l350 lab=WL[30]}
C {devices/lab_pin.sym} -40.0 3610.0 0 0 {name=l351 lab=WL[29]}
C {devices/lab_pin.sym} -40.0 3630.0 0 0 {name=l352 lab=WL[28]}
C {devices/lab_pin.sym} -40.0 3650.0 0 0 {name=l353 lab=WL[27]}
C {devices/lab_pin.sym} -40.0 3670.0 0 0 {name=l354 lab=WL[26]}
C {devices/lab_pin.sym} -40.0 3690.0 0 0 {name=l355 lab=WL[25]}
C {devices/lab_pin.sym} -40.0 3710.0 0 0 {name=l356 lab=WL[24]}
C {devices/lab_pin.sym} -40.0 3730.0 0 0 {name=l357 lab=WL[23]}
C {devices/lab_pin.sym} -40.0 3750.0 0 0 {name=l358 lab=WL[22]}
C {devices/lab_pin.sym} -40.0 3770.0 0 0 {name=l359 lab=WL[21]}
C {devices/lab_pin.sym} -40.0 3790.0 0 0 {name=l360 lab=WL[20]}
C {devices/lab_pin.sym} -40.0 3810.0 0 0 {name=l361 lab=WL[19]}
C {devices/lab_pin.sym} -40.0 3830.0 0 0 {name=l362 lab=WL[18]}
C {devices/lab_pin.sym} -40.0 3850.0 0 0 {name=l363 lab=WL[17]}
C {devices/lab_pin.sym} -40.0 3870.0 0 0 {name=l364 lab=WL[16]}
C {devices/lab_pin.sym} -40.0 3890.0 0 0 {name=l365 lab=WL[15]}
C {devices/lab_pin.sym} -40.0 3910.0 0 0 {name=l366 lab=WL[14]}
C {devices/lab_pin.sym} -40.0 3930.0 0 0 {name=l367 lab=WL[13]}
C {devices/lab_pin.sym} -40.0 3950.0 0 0 {name=l368 lab=WL[12]}
C {devices/lab_pin.sym} -40.0 3970.0 0 0 {name=l369 lab=WL[11]}
C {devices/lab_pin.sym} -40.0 3990.0 0 0 {name=l370 lab=WL[10]}
C {devices/lab_pin.sym} -40.0 4010.0 0 0 {name=l371 lab=WL[9]}
C {devices/lab_pin.sym} -40.0 4030.0 0 0 {name=l372 lab=WL[8]}
C {devices/lab_pin.sym} -40.0 4050.0 0 0 {name=l373 lab=WL[7]}
C {devices/lab_pin.sym} -40.0 4070.0 0 0 {name=l374 lab=WL[6]}
C {devices/lab_pin.sym} -40.0 4090.0 0 0 {name=l375 lab=WL[5]}
C {devices/lab_pin.sym} -40.0 4110.0 0 0 {name=l376 lab=WL[4]}
C {devices/lab_pin.sym} -40.0 4130.0 0 0 {name=l377 lab=WL[3]}
C {devices/lab_pin.sym} -40.0 4150.0 0 0 {name=l378 lab=WL[2]}
C {devices/lab_pin.sym} -40.0 4170.0 0 0 {name=l379 lab=WL[1]}
C {devices/lab_pin.sym} -40.0 4190.0 0 0 {name=l380 lab=WL[0]}
C {devices/lab_pin.sym} -40.0 4210.0 0 0 {name=l381 lab=DOUT[31:0]}
C {devices/lab_pin.sym} -40.0 4230.0 0 0 {name=l382 lab=DOUTB[31:0]}
C {devices/lab_pin.sym} -40.0 4250.0 0 0 {name=l383 lab=VDD}
C {devices/lab_pin.sym} -40.0 4270.0 0 0 {name=l384 lab=VSS}
C {latches/out_latch.sym} 400 2880 0 0 {name=XQL}
C {devices/lab_pin.sym} 360.0 2220.0 0 0 {name=l385 lab=SAE}
C {devices/lab_pin.sym} 360.0 2240.0 0 0 {name=l386 lab=DOUT[31]}
C {devices/lab_pin.sym} 360.0 2260.0 0 0 {name=l387 lab=DOUT[30]}
C {devices/lab_pin.sym} 360.0 2280.0 0 0 {name=l388 lab=DOUT[29]}
C {devices/lab_pin.sym} 360.0 2300.0 0 0 {name=l389 lab=DOUT[28]}
C {devices/lab_pin.sym} 360.0 2320.0 0 0 {name=l390 lab=DOUT[27]}
C {devices/lab_pin.sym} 360.0 2340.0 0 0 {name=l391 lab=DOUT[26]}
C {devices/lab_pin.sym} 360.0 2360.0 0 0 {name=l392 lab=DOUT[25]}
C {devices/lab_pin.sym} 360.0 2380.0 0 0 {name=l393 lab=DOUT[24]}
C {devices/lab_pin.sym} 360.0 2400.0 0 0 {name=l394 lab=DOUT[23]}
C {devices/lab_pin.sym} 360.0 2420.0 0 0 {name=l395 lab=DOUT[22]}
C {devices/lab_pin.sym} 360.0 2440.0 0 0 {name=l396 lab=DOUT[21]}
C {devices/lab_pin.sym} 360.0 2460.0 0 0 {name=l397 lab=DOUT[20]}
C {devices/lab_pin.sym} 360.0 2480.0 0 0 {name=l398 lab=DOUT[19]}
C {devices/lab_pin.sym} 360.0 2500.0 0 0 {name=l399 lab=DOUT[18]}
C {devices/lab_pin.sym} 360.0 2520.0 0 0 {name=l400 lab=DOUT[17]}
C {devices/lab_pin.sym} 360.0 2540.0 0 0 {name=l401 lab=DOUT[16]}
C {devices/lab_pin.sym} 360.0 2560.0 0 0 {name=l402 lab=DOUT[15]}
C {devices/lab_pin.sym} 360.0 2580.0 0 0 {name=l403 lab=DOUT[14]}
C {devices/lab_pin.sym} 360.0 2600.0 0 0 {name=l404 lab=DOUT[13]}
C {devices/lab_pin.sym} 360.0 2620.0 0 0 {name=l405 lab=DOUT[12]}
C {devices/lab_pin.sym} 360.0 2640.0 0 0 {name=l406 lab=DOUT[11]}
C {devices/lab_pin.sym} 360.0 2660.0 0 0 {name=l407 lab=DOUT[10]}
C {devices/lab_pin.sym} 360.0 2680.0 0 0 {name=l408 lab=DOUT[9]}
C {devices/lab_pin.sym} 360.0 2700.0 0 0 {name=l409 lab=DOUT[8]}
C {devices/lab_pin.sym} 360.0 2720.0 0 0 {name=l410 lab=DOUT[7]}
C {devices/lab_pin.sym} 360.0 2740.0 0 0 {name=l411 lab=DOUT[6]}
C {devices/lab_pin.sym} 360.0 2760.0 0 0 {name=l412 lab=DOUT[5]}
C {devices/lab_pin.sym} 360.0 2780.0 0 0 {name=l413 lab=DOUT[4]}
C {devices/lab_pin.sym} 360.0 2800.0 0 0 {name=l414 lab=DOUT[3]}
C {devices/lab_pin.sym} 360.0 2820.0 0 0 {name=l415 lab=DOUT[2]}
C {devices/lab_pin.sym} 360.0 2840.0 0 0 {name=l416 lab=DOUT[1]}
C {devices/lab_pin.sym} 360.0 2860.0 0 0 {name=l417 lab=DOUT[0]}
C {devices/lab_pin.sym} 360.0 2880.0 0 0 {name=l418 lab=Q[31]}
C {devices/lab_pin.sym} 360.0 2900.0 0 0 {name=l419 lab=Q[30]}
C {devices/lab_pin.sym} 360.0 2920.0 0 0 {name=l420 lab=Q[29]}
C {devices/lab_pin.sym} 360.0 2940.0 0 0 {name=l421 lab=Q[28]}
C {devices/lab_pin.sym} 360.0 2960.0 0 0 {name=l422 lab=Q[27]}
C {devices/lab_pin.sym} 360.0 2980.0 0 0 {name=l423 lab=Q[26]}
C {devices/lab_pin.sym} 360.0 3000.0 0 0 {name=l424 lab=Q[25]}
C {devices/lab_pin.sym} 360.0 3020.0 0 0 {name=l425 lab=Q[24]}
C {devices/lab_pin.sym} 360.0 3040.0 0 0 {name=l426 lab=Q[23]}
C {devices/lab_pin.sym} 360.0 3060.0 0 0 {name=l427 lab=Q[22]}
C {devices/lab_pin.sym} 360.0 3080.0 0 0 {name=l428 lab=Q[21]}
C {devices/lab_pin.sym} 360.0 3100.0 0 0 {name=l429 lab=Q[20]}
C {devices/lab_pin.sym} 360.0 3120.0 0 0 {name=l430 lab=Q[19]}
C {devices/lab_pin.sym} 360.0 3140.0 0 0 {name=l431 lab=Q[18]}
C {devices/lab_pin.sym} 360.0 3160.0 0 0 {name=l432 lab=Q[17]}
C {devices/lab_pin.sym} 360.0 3180.0 0 0 {name=l433 lab=Q[16]}
C {devices/lab_pin.sym} 360.0 3200.0 0 0 {name=l434 lab=Q[15]}
C {devices/lab_pin.sym} 360.0 3220.0 0 0 {name=l435 lab=Q[14]}
C {devices/lab_pin.sym} 360.0 3240.0 0 0 {name=l436 lab=Q[13]}
C {devices/lab_pin.sym} 360.0 3260.0 0 0 {name=l437 lab=Q[12]}
C {devices/lab_pin.sym} 360.0 3280.0 0 0 {name=l438 lab=Q[11]}
C {devices/lab_pin.sym} 360.0 3300.0 0 0 {name=l439 lab=Q[10]}
C {devices/lab_pin.sym} 360.0 3320.0 0 0 {name=l440 lab=Q[9]}
C {devices/lab_pin.sym} 360.0 3340.0 0 0 {name=l441 lab=Q[8]}
C {devices/lab_pin.sym} 360.0 3360.0 0 0 {name=l442 lab=Q[7]}
C {devices/lab_pin.sym} 360.0 3380.0 0 0 {name=l443 lab=Q[6]}
C {devices/lab_pin.sym} 360.0 3400.0 0 0 {name=l444 lab=Q[5]}
C {devices/lab_pin.sym} 360.0 3420.0 0 0 {name=l445 lab=Q[4]}
C {devices/lab_pin.sym} 360.0 3440.0 0 0 {name=l446 lab=Q[3]}
C {devices/lab_pin.sym} 360.0 3460.0 0 0 {name=l447 lab=Q[2]}
C {devices/lab_pin.sym} 360.0 3480.0 0 0 {name=l448 lab=Q[1]}
C {devices/lab_pin.sym} 360.0 3500.0 0 0 {name=l449 lab=Q[0]}
C {devices/lab_pin.sym} 360.0 3520.0 0 0 {name=l450 lab=VDD}
C {devices/lab_pin.sym} 360.0 3540.0 0 0 {name=l451 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=p452 lab=A[7]}
C {devices/ipin.sym} -900 -260 0 0 {name=p453 lab=A[6]}
C {devices/ipin.sym} -900 -220 0 0 {name=p454 lab=A[5]}
C {devices/ipin.sym} -900 -180 0 0 {name=p455 lab=A[4]}
C {devices/ipin.sym} -900 -140 0 0 {name=p456 lab=A[3]}
C {devices/ipin.sym} -900 -100 0 0 {name=p457 lab=A[2]}
C {devices/ipin.sym} -900 -60 0 0 {name=p458 lab=A[1]}
C {devices/ipin.sym} -900 -20 0 0 {name=p459 lab=A[0]}
C {devices/ipin.sym} -900 20 0 0 {name=p460 lab=CEN}
C {devices/ipin.sym} -900 60 0 0 {name=p461 lab=CLK}
C {devices/ipin.sym} -900 100 0 0 {name=p462 lab=D[31]}
C {devices/ipin.sym} -900 140 0 0 {name=p463 lab=D[30]}
C {devices/ipin.sym} -900 180 0 0 {name=p464 lab=D[29]}
C {devices/ipin.sym} -900 220 0 0 {name=p465 lab=D[28]}
C {devices/ipin.sym} -900 260 0 0 {name=p466 lab=D[27]}
C {devices/ipin.sym} -900 300 0 0 {name=p467 lab=D[26]}
C {devices/ipin.sym} -900 340 0 0 {name=p468 lab=D[25]}
C {devices/ipin.sym} -900 380 0 0 {name=p469 lab=D[24]}
C {devices/ipin.sym} -900 420 0 0 {name=p470 lab=D[23]}
C {devices/ipin.sym} -900 460 0 0 {name=p471 lab=D[22]}
C {devices/ipin.sym} -900 500 0 0 {name=p472 lab=D[21]}
C {devices/ipin.sym} -900 540 0 0 {name=p473 lab=D[20]}
C {devices/ipin.sym} -900 580 0 0 {name=p474 lab=D[19]}
C {devices/ipin.sym} -900 620 0 0 {name=p475 lab=D[18]}
C {devices/ipin.sym} -900 660 0 0 {name=p476 lab=D[17]}
C {devices/ipin.sym} -900 700 0 0 {name=p477 lab=D[16]}
C {devices/ipin.sym} -900 740 0 0 {name=p478 lab=D[15]}
C {devices/ipin.sym} -900 780 0 0 {name=p479 lab=D[14]}
C {devices/ipin.sym} -900 820 0 0 {name=p480 lab=D[13]}
C {devices/ipin.sym} -900 860 0 0 {name=p481 lab=D[12]}
C {devices/ipin.sym} -900 900 0 0 {name=p482 lab=D[11]}
C {devices/ipin.sym} -900 940 0 0 {name=p483 lab=D[10]}
C {devices/ipin.sym} -900 980 0 0 {name=p484 lab=D[9]}
C {devices/ipin.sym} -900 1020 0 0 {name=p485 lab=D[8]}
C {devices/ipin.sym} -900 1060 0 0 {name=p486 lab=D[7]}
C {devices/ipin.sym} -900 1100 0 0 {name=p487 lab=D[6]}
C {devices/ipin.sym} -900 1140 0 0 {name=p488 lab=D[5]}
C {devices/ipin.sym} -900 1180 0 0 {name=p489 lab=D[4]}
C {devices/ipin.sym} -900 1220 0 0 {name=p490 lab=D[3]}
C {devices/ipin.sym} -900 1260 0 0 {name=p491 lab=D[2]}
C {devices/ipin.sym} -900 1300 0 0 {name=p492 lab=D[1]}
C {devices/ipin.sym} -900 1340 0 0 {name=p493 lab=D[0]}
C {devices/opin.sym} -900 1380 0 0 {name=p494 lab=Q[31]}
C {devices/opin.sym} -900 1420 0 0 {name=p495 lab=Q[30]}
C {devices/opin.sym} -900 1460 0 0 {name=p496 lab=Q[29]}
C {devices/opin.sym} -900 1500 0 0 {name=p497 lab=Q[28]}
C {devices/opin.sym} -900 1540 0 0 {name=p498 lab=Q[27]}
C {devices/opin.sym} -900 1580 0 0 {name=p499 lab=Q[26]}
C {devices/opin.sym} -900 1620 0 0 {name=p500 lab=Q[25]}
C {devices/opin.sym} -900 1660 0 0 {name=p501 lab=Q[24]}
C {devices/opin.sym} -900 1700 0 0 {name=p502 lab=Q[23]}
C {devices/opin.sym} -900 1740 0 0 {name=p503 lab=Q[22]}
C {devices/opin.sym} -900 1780 0 0 {name=p504 lab=Q[21]}
C {devices/opin.sym} -900 1820 0 0 {name=p505 lab=Q[20]}
C {devices/opin.sym} -900 1860 0 0 {name=p506 lab=Q[19]}
C {devices/opin.sym} -900 1900 0 0 {name=p507 lab=Q[18]}
C {devices/opin.sym} -900 1940 0 0 {name=p508 lab=Q[17]}
C {devices/opin.sym} -900 1980 0 0 {name=p509 lab=Q[16]}
C {devices/opin.sym} -900 2020 0 0 {name=p510 lab=Q[15]}
C {devices/opin.sym} -900 2060 0 0 {name=p511 lab=Q[14]}
C {devices/opin.sym} -900 2100 0 0 {name=p512 lab=Q[13]}
C {devices/opin.sym} -900 2140 0 0 {name=p513 lab=Q[12]}
C {devices/opin.sym} -900 2180 0 0 {name=p514 lab=Q[11]}
C {devices/opin.sym} -900 2220 0 0 {name=p515 lab=Q[10]}
C {devices/opin.sym} -900 2260 0 0 {name=p516 lab=Q[9]}
C {devices/opin.sym} -900 2300 0 0 {name=p517 lab=Q[8]}
C {devices/opin.sym} -900 2340 0 0 {name=p518 lab=Q[7]}
C {devices/opin.sym} -900 2380 0 0 {name=p519 lab=Q[6]}
C {devices/opin.sym} -900 2420 0 0 {name=p520 lab=Q[5]}
C {devices/opin.sym} -900 2460 0 0 {name=p521 lab=Q[4]}
C {devices/opin.sym} -900 2500 0 0 {name=p522 lab=Q[3]}
C {devices/opin.sym} -900 2540 0 0 {name=p523 lab=Q[2]}
C {devices/opin.sym} -900 2580 0 0 {name=p524 lab=Q[1]}
C {devices/opin.sym} -900 2620 0 0 {name=p525 lab=Q[0]}
C {devices/ipin.sym} -900 2660 0 0 {name=p526 lab=GWEN}
C {devices/ipin.sym} -900 2700 0 0 {name=p527 lab=WEN}
C {devices/iopin.sym} -900 2740 0 0 {name=p528 lab=VDD}
C {devices/iopin.sym} -900 2780 0 0 {name=p529 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* 256 x 32 SRAM macro (128 rows x 64 columns, mux 2): A[0] selects the column, A[7:1] the row; one supply rail VDD/VSS"}
