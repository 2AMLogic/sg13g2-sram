v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {latches/addr_latch.sym} 0 0 0 0 {name=XAL}
C {devices/lab_pin.sym} -40 -220 0 0 {name=lw1 lab=CLK}
C {devices/lab_pin.sym} -40 -200 0 0 {name=lw2 lab=A[7]}
C {devices/lab_pin.sym} -40 -180 0 0 {name=lw3 lab=A[6]}
C {devices/lab_pin.sym} -40 -160 0 0 {name=lw4 lab=A[5]}
C {devices/lab_pin.sym} -40 -140 0 0 {name=lw5 lab=A[4]}
C {devices/lab_pin.sym} -40 -120 0 0 {name=lw6 lab=A[3]}
C {devices/lab_pin.sym} -40 -100 0 0 {name=lw7 lab=A[2]}
C {devices/lab_pin.sym} -40 -80 0 0 {name=lw8 lab=A[1]}
C {devices/lab_pin.sym} -40 -60 0 0 {name=lw9 lab=A[0]}
C {devices/lab_pin.sym} -40 -40 0 0 {name=lw10 lab=CEN}
C {devices/lab_pin.sym} -40 -20 0 0 {name=lw11 lab=GWEN}
C {devices/lab_pin.sym} -40 0 0 0 {name=lw12 lab=AL[7]}
C {devices/lab_pin.sym} -40 20 0 0 {name=lw13 lab=AL[6]}
C {devices/lab_pin.sym} -40 40 0 0 {name=lw14 lab=AL[5]}
C {devices/lab_pin.sym} -40 60 0 0 {name=lw15 lab=AL[4]}
C {devices/lab_pin.sym} -40 80 0 0 {name=lw16 lab=AL[3]}
C {devices/lab_pin.sym} -40 100 0 0 {name=lw17 lab=AL[2]}
C {devices/lab_pin.sym} -40 120 0 0 {name=lw18 lab=AL[1]}
C {devices/lab_pin.sym} -40 140 0 0 {name=lw19 lab=AL[0]}
C {devices/lab_pin.sym} -40 160 0 0 {name=lw20 lab=CENL}
C {devices/lab_pin.sym} -40 180 0 0 {name=lw21 lab=GWENL}
C {devices/lab_pin.sym} -40 200 0 0 {name=lw22 lab=VDD}
C {devices/lab_pin.sym} -40 220 0 0 {name=lw23 lab=VSS}
C {control/control.sym} 400 0 0 0 {name=XCTL}
C {devices/lab_pin.sym} 360 -130 0 0 {name=lw24 lab=CLK}
C {devices/lab_pin.sym} 360 -110 0 0 {name=lw25 lab=CENL}
C {devices/lab_pin.sym} 360 -90 0 0 {name=lw26 lab=GWENL}
C {devices/lab_pin.sym} 360 -70 0 0 {name=lw27 lab=AL[0]}
C {devices/lab_pin.sym} 360 -50 0 0 {name=lw28 lab=PRE_B}
C {devices/lab_pin.sym} 360 -30 0 0 {name=lw29 lab=WLEN}
C {devices/lab_pin.sym} 360 -10 0 0 {name=lw30 lab=SAE}
C {devices/lab_pin.sym} 360 10 0 0 {name=lw31 lab=WE}
C {devices/lab_pin.sym} 360 30 0 0 {name=lw32 lab=SEL0}
C {devices/lab_pin.sym} 360 50 0 0 {name=lw33 lab=SEL0B}
C {devices/lab_pin.sym} 360 70 0 0 {name=lw34 lab=SEL1}
C {devices/lab_pin.sym} 360 90 0 0 {name=lw35 lab=SEL1B}
C {devices/lab_pin.sym} 360 110 0 0 {name=lw36 lab=VDD}
C {devices/lab_pin.sym} 360 130 0 0 {name=lw37 lab=VSS}
C {decoder/row_decoder.sym} 800 0 0 0 {name=XDEC}
C {devices/lab_pin.sym} 760.0 -1370.0 0 0 {name=l40 lab=AL[7]}
C {devices/lab_pin.sym} 760.0 -1350.0 0 0 {name=l41 lab=AL[6]}
C {devices/lab_pin.sym} 760.0 -1330.0 0 0 {name=l42 lab=AL[5]}
C {devices/lab_pin.sym} 760.0 -1310.0 0 0 {name=l43 lab=AL[4]}
C {devices/lab_pin.sym} 760.0 -1290.0 0 0 {name=l44 lab=AL[3]}
C {devices/lab_pin.sym} 760.0 -1270.0 0 0 {name=l45 lab=AL[2]}
C {devices/lab_pin.sym} 760.0 -1250.0 0 0 {name=l46 lab=AL[1]}
C {devices/lab_pin.sym} 760.0 -1230.0 0 0 {name=l47 lab=WLEN}
C {devices/lab_pin.sym} 760.0 -1210.0 0 0 {name=l48 lab=WL[127]}
C {devices/lab_pin.sym} 760.0 -1190.0 0 0 {name=l49 lab=WL[126]}
C {devices/lab_pin.sym} 760.0 -1170.0 0 0 {name=l50 lab=WL[125]}
C {devices/lab_pin.sym} 760.0 -1150.0 0 0 {name=l51 lab=WL[124]}
C {devices/lab_pin.sym} 760.0 -1130.0 0 0 {name=l52 lab=WL[123]}
C {devices/lab_pin.sym} 760.0 -1110.0 0 0 {name=l53 lab=WL[122]}
C {devices/lab_pin.sym} 760.0 -1090.0 0 0 {name=l54 lab=WL[121]}
C {devices/lab_pin.sym} 760.0 -1070.0 0 0 {name=l55 lab=WL[120]}
C {devices/lab_pin.sym} 760.0 -1050.0 0 0 {name=l56 lab=WL[119]}
C {devices/lab_pin.sym} 760.0 -1030.0 0 0 {name=l57 lab=WL[118]}
C {devices/lab_pin.sym} 760.0 -1010.0 0 0 {name=l58 lab=WL[117]}
C {devices/lab_pin.sym} 760.0 -990.0 0 0 {name=l59 lab=WL[116]}
C {devices/lab_pin.sym} 760.0 -970.0 0 0 {name=l60 lab=WL[115]}
C {devices/lab_pin.sym} 760.0 -950.0 0 0 {name=l61 lab=WL[114]}
C {devices/lab_pin.sym} 760.0 -930.0 0 0 {name=l62 lab=WL[113]}
C {devices/lab_pin.sym} 760.0 -910.0 0 0 {name=l63 lab=WL[112]}
C {devices/lab_pin.sym} 760.0 -890.0 0 0 {name=l64 lab=WL[111]}
C {devices/lab_pin.sym} 760.0 -870.0 0 0 {name=l65 lab=WL[110]}
C {devices/lab_pin.sym} 760.0 -850.0 0 0 {name=l66 lab=WL[109]}
C {devices/lab_pin.sym} 760.0 -830.0 0 0 {name=l67 lab=WL[108]}
C {devices/lab_pin.sym} 760.0 -810.0 0 0 {name=l68 lab=WL[107]}
C {devices/lab_pin.sym} 760.0 -790.0 0 0 {name=l69 lab=WL[106]}
C {devices/lab_pin.sym} 760.0 -770.0 0 0 {name=l70 lab=WL[105]}
C {devices/lab_pin.sym} 760.0 -750.0 0 0 {name=l71 lab=WL[104]}
C {devices/lab_pin.sym} 760.0 -730.0 0 0 {name=l72 lab=WL[103]}
C {devices/lab_pin.sym} 760.0 -710.0 0 0 {name=l73 lab=WL[102]}
C {devices/lab_pin.sym} 760.0 -690.0 0 0 {name=l74 lab=WL[101]}
C {devices/lab_pin.sym} 760.0 -670.0 0 0 {name=l75 lab=WL[100]}
C {devices/lab_pin.sym} 760.0 -650.0 0 0 {name=l76 lab=WL[99]}
C {devices/lab_pin.sym} 760.0 -630.0 0 0 {name=l77 lab=WL[98]}
C {devices/lab_pin.sym} 760.0 -610.0 0 0 {name=l78 lab=WL[97]}
C {devices/lab_pin.sym} 760.0 -590.0 0 0 {name=l79 lab=WL[96]}
C {devices/lab_pin.sym} 760.0 -570.0 0 0 {name=l80 lab=WL[95]}
C {devices/lab_pin.sym} 760.0 -550.0 0 0 {name=l81 lab=WL[94]}
C {devices/lab_pin.sym} 760.0 -530.0 0 0 {name=l82 lab=WL[93]}
C {devices/lab_pin.sym} 760.0 -510.0 0 0 {name=l83 lab=WL[92]}
C {devices/lab_pin.sym} 760.0 -490.0 0 0 {name=l84 lab=WL[91]}
C {devices/lab_pin.sym} 760.0 -470.0 0 0 {name=l85 lab=WL[90]}
C {devices/lab_pin.sym} 760.0 -450.0 0 0 {name=l86 lab=WL[89]}
C {devices/lab_pin.sym} 760.0 -430.0 0 0 {name=l87 lab=WL[88]}
C {devices/lab_pin.sym} 760.0 -410.0 0 0 {name=l88 lab=WL[87]}
C {devices/lab_pin.sym} 760.0 -390.0 0 0 {name=l89 lab=WL[86]}
C {devices/lab_pin.sym} 760.0 -370.0 0 0 {name=l90 lab=WL[85]}
C {devices/lab_pin.sym} 760.0 -350.0 0 0 {name=l91 lab=WL[84]}
C {devices/lab_pin.sym} 760.0 -330.0 0 0 {name=l92 lab=WL[83]}
C {devices/lab_pin.sym} 760.0 -310.0 0 0 {name=l93 lab=WL[82]}
C {devices/lab_pin.sym} 760.0 -290.0 0 0 {name=l94 lab=WL[81]}
C {devices/lab_pin.sym} 760.0 -270.0 0 0 {name=l95 lab=WL[80]}
C {devices/lab_pin.sym} 760.0 -250.0 0 0 {name=l96 lab=WL[79]}
C {devices/lab_pin.sym} 760.0 -230.0 0 0 {name=l97 lab=WL[78]}
C {devices/lab_pin.sym} 760.0 -210.0 0 0 {name=l98 lab=WL[77]}
C {devices/lab_pin.sym} 760.0 -190.0 0 0 {name=l99 lab=WL[76]}
C {devices/lab_pin.sym} 760.0 -170.0 0 0 {name=l100 lab=WL[75]}
C {devices/lab_pin.sym} 760.0 -150.0 0 0 {name=l101 lab=WL[74]}
C {devices/lab_pin.sym} 760.0 -130.0 0 0 {name=l102 lab=WL[73]}
C {devices/lab_pin.sym} 760.0 -110.0 0 0 {name=l103 lab=WL[72]}
C {devices/lab_pin.sym} 760.0 -90.0 0 0 {name=l104 lab=WL[71]}
C {devices/lab_pin.sym} 760.0 -70.0 0 0 {name=l105 lab=WL[70]}
C {devices/lab_pin.sym} 760.0 -50.0 0 0 {name=l106 lab=WL[69]}
C {devices/lab_pin.sym} 760.0 -30.0 0 0 {name=l107 lab=WL[68]}
C {devices/lab_pin.sym} 760.0 -10.0 0 0 {name=l108 lab=WL[67]}
C {devices/lab_pin.sym} 760.0 10.0 0 0 {name=l109 lab=WL[66]}
C {devices/lab_pin.sym} 760.0 30.0 0 0 {name=l110 lab=WL[65]}
C {devices/lab_pin.sym} 760.0 50.0 0 0 {name=l111 lab=WL[64]}
C {devices/lab_pin.sym} 760.0 70.0 0 0 {name=l112 lab=WL[63]}
C {devices/lab_pin.sym} 760.0 90.0 0 0 {name=l113 lab=WL[62]}
C {devices/lab_pin.sym} 760.0 110.0 0 0 {name=l114 lab=WL[61]}
C {devices/lab_pin.sym} 760.0 130.0 0 0 {name=l115 lab=WL[60]}
C {devices/lab_pin.sym} 760.0 150.0 0 0 {name=l116 lab=WL[59]}
C {devices/lab_pin.sym} 760.0 170.0 0 0 {name=l117 lab=WL[58]}
C {devices/lab_pin.sym} 760.0 190.0 0 0 {name=l118 lab=WL[57]}
C {devices/lab_pin.sym} 760.0 210.0 0 0 {name=l119 lab=WL[56]}
C {devices/lab_pin.sym} 760.0 230.0 0 0 {name=l120 lab=WL[55]}
C {devices/lab_pin.sym} 760.0 250.0 0 0 {name=l121 lab=WL[54]}
C {devices/lab_pin.sym} 760.0 270.0 0 0 {name=l122 lab=WL[53]}
C {devices/lab_pin.sym} 760.0 290.0 0 0 {name=l123 lab=WL[52]}
C {devices/lab_pin.sym} 760.0 310.0 0 0 {name=l124 lab=WL[51]}
C {devices/lab_pin.sym} 760.0 330.0 0 0 {name=l125 lab=WL[50]}
C {devices/lab_pin.sym} 760.0 350.0 0 0 {name=l126 lab=WL[49]}
C {devices/lab_pin.sym} 760.0 370.0 0 0 {name=l127 lab=WL[48]}
C {devices/lab_pin.sym} 760.0 390.0 0 0 {name=l128 lab=WL[47]}
C {devices/lab_pin.sym} 760.0 410.0 0 0 {name=l129 lab=WL[46]}
C {devices/lab_pin.sym} 760.0 430.0 0 0 {name=l130 lab=WL[45]}
C {devices/lab_pin.sym} 760.0 450.0 0 0 {name=l131 lab=WL[44]}
C {devices/lab_pin.sym} 760.0 470.0 0 0 {name=l132 lab=WL[43]}
C {devices/lab_pin.sym} 760.0 490.0 0 0 {name=l133 lab=WL[42]}
C {devices/lab_pin.sym} 760.0 510.0 0 0 {name=l134 lab=WL[41]}
C {devices/lab_pin.sym} 760.0 530.0 0 0 {name=l135 lab=WL[40]}
C {devices/lab_pin.sym} 760.0 550.0 0 0 {name=l136 lab=WL[39]}
C {devices/lab_pin.sym} 760.0 570.0 0 0 {name=l137 lab=WL[38]}
C {devices/lab_pin.sym} 760.0 590.0 0 0 {name=l138 lab=WL[37]}
C {devices/lab_pin.sym} 760.0 610.0 0 0 {name=l139 lab=WL[36]}
C {devices/lab_pin.sym} 760.0 630.0 0 0 {name=l140 lab=WL[35]}
C {devices/lab_pin.sym} 760.0 650.0 0 0 {name=l141 lab=WL[34]}
C {devices/lab_pin.sym} 760.0 670.0 0 0 {name=l142 lab=WL[33]}
C {devices/lab_pin.sym} 760.0 690.0 0 0 {name=l143 lab=WL[32]}
C {devices/lab_pin.sym} 760.0 710.0 0 0 {name=l144 lab=WL[31]}
C {devices/lab_pin.sym} 760.0 730.0 0 0 {name=l145 lab=WL[30]}
C {devices/lab_pin.sym} 760.0 750.0 0 0 {name=l146 lab=WL[29]}
C {devices/lab_pin.sym} 760.0 770.0 0 0 {name=l147 lab=WL[28]}
C {devices/lab_pin.sym} 760.0 790.0 0 0 {name=l148 lab=WL[27]}
C {devices/lab_pin.sym} 760.0 810.0 0 0 {name=l149 lab=WL[26]}
C {devices/lab_pin.sym} 760.0 830.0 0 0 {name=l150 lab=WL[25]}
C {devices/lab_pin.sym} 760.0 850.0 0 0 {name=l151 lab=WL[24]}
C {devices/lab_pin.sym} 760.0 870.0 0 0 {name=l152 lab=WL[23]}
C {devices/lab_pin.sym} 760.0 890.0 0 0 {name=l153 lab=WL[22]}
C {devices/lab_pin.sym} 760.0 910.0 0 0 {name=l154 lab=WL[21]}
C {devices/lab_pin.sym} 760.0 930.0 0 0 {name=l155 lab=WL[20]}
C {devices/lab_pin.sym} 760.0 950.0 0 0 {name=l156 lab=WL[19]}
C {devices/lab_pin.sym} 760.0 970.0 0 0 {name=l157 lab=WL[18]}
C {devices/lab_pin.sym} 760.0 990.0 0 0 {name=l158 lab=WL[17]}
C {devices/lab_pin.sym} 760.0 1010.0 0 0 {name=l159 lab=WL[16]}
C {devices/lab_pin.sym} 760.0 1030.0 0 0 {name=l160 lab=WL[15]}
C {devices/lab_pin.sym} 760.0 1050.0 0 0 {name=l161 lab=WL[14]}
C {devices/lab_pin.sym} 760.0 1070.0 0 0 {name=l162 lab=WL[13]}
C {devices/lab_pin.sym} 760.0 1090.0 0 0 {name=l163 lab=WL[12]}
C {devices/lab_pin.sym} 760.0 1110.0 0 0 {name=l164 lab=WL[11]}
C {devices/lab_pin.sym} 760.0 1130.0 0 0 {name=l165 lab=WL[10]}
C {devices/lab_pin.sym} 760.0 1150.0 0 0 {name=l166 lab=WL[9]}
C {devices/lab_pin.sym} 760.0 1170.0 0 0 {name=l167 lab=WL[8]}
C {devices/lab_pin.sym} 760.0 1190.0 0 0 {name=l168 lab=WL[7]}
C {devices/lab_pin.sym} 760.0 1210.0 0 0 {name=l169 lab=WL[6]}
C {devices/lab_pin.sym} 760.0 1230.0 0 0 {name=l170 lab=WL[5]}
C {devices/lab_pin.sym} 760.0 1250.0 0 0 {name=l171 lab=WL[4]}
C {devices/lab_pin.sym} 760.0 1270.0 0 0 {name=l172 lab=WL[3]}
C {devices/lab_pin.sym} 760.0 1290.0 0 0 {name=l173 lab=WL[2]}
C {devices/lab_pin.sym} 760.0 1310.0 0 0 {name=l174 lab=WL[1]}
C {devices/lab_pin.sym} 760.0 1330.0 0 0 {name=l175 lab=WL[0]}
C {devices/lab_pin.sym} 760.0 1350.0 0 0 {name=l176 lab=VDD}
C {devices/lab_pin.sym} 760.0 1370.0 0 0 {name=l177 lab=VSS}
C {latches/data_latch.sym} 1200 0 0 0 {name=XDL}
C {devices/lab_pin.sym} 1160 -1300 0 0 {name=lw38 lab=CLK}
C {devices/lab_pin.sym} 1160 -1280 0 0 {name=lw39 lab=D[31]}
C {devices/lab_pin.sym} 1160 -1260 0 0 {name=lw40 lab=D[30]}
C {devices/lab_pin.sym} 1160 -1240 0 0 {name=lw41 lab=D[29]}
C {devices/lab_pin.sym} 1160 -1220 0 0 {name=lw42 lab=D[28]}
C {devices/lab_pin.sym} 1160 -1200 0 0 {name=lw43 lab=D[27]}
C {devices/lab_pin.sym} 1160 -1180 0 0 {name=lw44 lab=D[26]}
C {devices/lab_pin.sym} 1160 -1160 0 0 {name=lw45 lab=D[25]}
C {devices/lab_pin.sym} 1160 -1140 0 0 {name=lw46 lab=D[24]}
C {devices/lab_pin.sym} 1160 -1120 0 0 {name=lw47 lab=D[23]}
C {devices/lab_pin.sym} 1160 -1100 0 0 {name=lw48 lab=D[22]}
C {devices/lab_pin.sym} 1160 -1080 0 0 {name=lw49 lab=D[21]}
C {devices/lab_pin.sym} 1160 -1060 0 0 {name=lw50 lab=D[20]}
C {devices/lab_pin.sym} 1160 -1040 0 0 {name=lw51 lab=D[19]}
C {devices/lab_pin.sym} 1160 -1020 0 0 {name=lw52 lab=D[18]}
C {devices/lab_pin.sym} 1160 -1000 0 0 {name=lw53 lab=D[17]}
C {devices/lab_pin.sym} 1160 -980 0 0 {name=lw54 lab=D[16]}
C {devices/lab_pin.sym} 1160 -960 0 0 {name=lw55 lab=D[15]}
C {devices/lab_pin.sym} 1160 -940 0 0 {name=lw56 lab=D[14]}
C {devices/lab_pin.sym} 1160 -920 0 0 {name=lw57 lab=D[13]}
C {devices/lab_pin.sym} 1160 -900 0 0 {name=lw58 lab=D[12]}
C {devices/lab_pin.sym} 1160 -880 0 0 {name=lw59 lab=D[11]}
C {devices/lab_pin.sym} 1160 -860 0 0 {name=lw60 lab=D[10]}
C {devices/lab_pin.sym} 1160 -840 0 0 {name=lw61 lab=D[9]}
C {devices/lab_pin.sym} 1160 -820 0 0 {name=lw62 lab=D[8]}
C {devices/lab_pin.sym} 1160 -800 0 0 {name=lw63 lab=D[7]}
C {devices/lab_pin.sym} 1160 -780 0 0 {name=lw64 lab=D[6]}
C {devices/lab_pin.sym} 1160 -760 0 0 {name=lw65 lab=D[5]}
C {devices/lab_pin.sym} 1160 -740 0 0 {name=lw66 lab=D[4]}
C {devices/lab_pin.sym} 1160 -720 0 0 {name=lw67 lab=D[3]}
C {devices/lab_pin.sym} 1160 -700 0 0 {name=lw68 lab=D[2]}
C {devices/lab_pin.sym} 1160 -680 0 0 {name=lw69 lab=D[1]}
C {devices/lab_pin.sym} 1160 -660 0 0 {name=lw70 lab=D[0]}
C {devices/lab_pin.sym} 1160 -640 0 0 {name=lw71 lab=WEN[31]}
C {devices/lab_pin.sym} 1160 -620 0 0 {name=lw72 lab=WEN[30]}
C {devices/lab_pin.sym} 1160 -600 0 0 {name=lw73 lab=WEN[29]}
C {devices/lab_pin.sym} 1160 -580 0 0 {name=lw74 lab=WEN[28]}
C {devices/lab_pin.sym} 1160 -560 0 0 {name=lw75 lab=WEN[27]}
C {devices/lab_pin.sym} 1160 -540 0 0 {name=lw76 lab=WEN[26]}
C {devices/lab_pin.sym} 1160 -520 0 0 {name=lw77 lab=WEN[25]}
C {devices/lab_pin.sym} 1160 -500 0 0 {name=lw78 lab=WEN[24]}
C {devices/lab_pin.sym} 1160 -480 0 0 {name=lw79 lab=WEN[23]}
C {devices/lab_pin.sym} 1160 -460 0 0 {name=lw80 lab=WEN[22]}
C {devices/lab_pin.sym} 1160 -440 0 0 {name=lw81 lab=WEN[21]}
C {devices/lab_pin.sym} 1160 -420 0 0 {name=lw82 lab=WEN[20]}
C {devices/lab_pin.sym} 1160 -400 0 0 {name=lw83 lab=WEN[19]}
C {devices/lab_pin.sym} 1160 -380 0 0 {name=lw84 lab=WEN[18]}
C {devices/lab_pin.sym} 1160 -360 0 0 {name=lw85 lab=WEN[17]}
C {devices/lab_pin.sym} 1160 -340 0 0 {name=lw86 lab=WEN[16]}
C {devices/lab_pin.sym} 1160 -320 0 0 {name=lw87 lab=WEN[15]}
C {devices/lab_pin.sym} 1160 -300 0 0 {name=lw88 lab=WEN[14]}
C {devices/lab_pin.sym} 1160 -280 0 0 {name=lw89 lab=WEN[13]}
C {devices/lab_pin.sym} 1160 -260 0 0 {name=lw90 lab=WEN[12]}
C {devices/lab_pin.sym} 1160 -240 0 0 {name=lw91 lab=WEN[11]}
C {devices/lab_pin.sym} 1160 -220 0 0 {name=lw92 lab=WEN[10]}
C {devices/lab_pin.sym} 1160 -200 0 0 {name=lw93 lab=WEN[9]}
C {devices/lab_pin.sym} 1160 -180 0 0 {name=lw94 lab=WEN[8]}
C {devices/lab_pin.sym} 1160 -160 0 0 {name=lw95 lab=WEN[7]}
C {devices/lab_pin.sym} 1160 -140 0 0 {name=lw96 lab=WEN[6]}
C {devices/lab_pin.sym} 1160 -120 0 0 {name=lw97 lab=WEN[5]}
C {devices/lab_pin.sym} 1160 -100 0 0 {name=lw98 lab=WEN[4]}
C {devices/lab_pin.sym} 1160 -80 0 0 {name=lw99 lab=WEN[3]}
C {devices/lab_pin.sym} 1160 -60 0 0 {name=lw100 lab=WEN[2]}
C {devices/lab_pin.sym} 1160 -40 0 0 {name=lw101 lab=WEN[1]}
C {devices/lab_pin.sym} 1160 -20 0 0 {name=lw102 lab=WEN[0]}
C {devices/lab_pin.sym} 1160 0 0 0 {name=lw103 lab=DL[31]}
C {devices/lab_pin.sym} 1160 20 0 0 {name=lw104 lab=DL[30]}
C {devices/lab_pin.sym} 1160 40 0 0 {name=lw105 lab=DL[29]}
C {devices/lab_pin.sym} 1160 60 0 0 {name=lw106 lab=DL[28]}
C {devices/lab_pin.sym} 1160 80 0 0 {name=lw107 lab=DL[27]}
C {devices/lab_pin.sym} 1160 100 0 0 {name=lw108 lab=DL[26]}
C {devices/lab_pin.sym} 1160 120 0 0 {name=lw109 lab=DL[25]}
C {devices/lab_pin.sym} 1160 140 0 0 {name=lw110 lab=DL[24]}
C {devices/lab_pin.sym} 1160 160 0 0 {name=lw111 lab=DL[23]}
C {devices/lab_pin.sym} 1160 180 0 0 {name=lw112 lab=DL[22]}
C {devices/lab_pin.sym} 1160 200 0 0 {name=lw113 lab=DL[21]}
C {devices/lab_pin.sym} 1160 220 0 0 {name=lw114 lab=DL[20]}
C {devices/lab_pin.sym} 1160 240 0 0 {name=lw115 lab=DL[19]}
C {devices/lab_pin.sym} 1160 260 0 0 {name=lw116 lab=DL[18]}
C {devices/lab_pin.sym} 1160 280 0 0 {name=lw117 lab=DL[17]}
C {devices/lab_pin.sym} 1160 300 0 0 {name=lw118 lab=DL[16]}
C {devices/lab_pin.sym} 1160 320 0 0 {name=lw119 lab=DL[15]}
C {devices/lab_pin.sym} 1160 340 0 0 {name=lw120 lab=DL[14]}
C {devices/lab_pin.sym} 1160 360 0 0 {name=lw121 lab=DL[13]}
C {devices/lab_pin.sym} 1160 380 0 0 {name=lw122 lab=DL[12]}
C {devices/lab_pin.sym} 1160 400 0 0 {name=lw123 lab=DL[11]}
C {devices/lab_pin.sym} 1160 420 0 0 {name=lw124 lab=DL[10]}
C {devices/lab_pin.sym} 1160 440 0 0 {name=lw125 lab=DL[9]}
C {devices/lab_pin.sym} 1160 460 0 0 {name=lw126 lab=DL[8]}
C {devices/lab_pin.sym} 1160 480 0 0 {name=lw127 lab=DL[7]}
C {devices/lab_pin.sym} 1160 500 0 0 {name=lw128 lab=DL[6]}
C {devices/lab_pin.sym} 1160 520 0 0 {name=lw129 lab=DL[5]}
C {devices/lab_pin.sym} 1160 540 0 0 {name=lw130 lab=DL[4]}
C {devices/lab_pin.sym} 1160 560 0 0 {name=lw131 lab=DL[3]}
C {devices/lab_pin.sym} 1160 580 0 0 {name=lw132 lab=DL[2]}
C {devices/lab_pin.sym} 1160 600 0 0 {name=lw133 lab=DL[1]}
C {devices/lab_pin.sym} 1160 620 0 0 {name=lw134 lab=DL[0]}
C {devices/lab_pin.sym} 1160 640 0 0 {name=lw135 lab=WENL[31]}
C {devices/lab_pin.sym} 1160 660 0 0 {name=lw136 lab=WENL[30]}
C {devices/lab_pin.sym} 1160 680 0 0 {name=lw137 lab=WENL[29]}
C {devices/lab_pin.sym} 1160 700 0 0 {name=lw138 lab=WENL[28]}
C {devices/lab_pin.sym} 1160 720 0 0 {name=lw139 lab=WENL[27]}
C {devices/lab_pin.sym} 1160 740 0 0 {name=lw140 lab=WENL[26]}
C {devices/lab_pin.sym} 1160 760 0 0 {name=lw141 lab=WENL[25]}
C {devices/lab_pin.sym} 1160 780 0 0 {name=lw142 lab=WENL[24]}
C {devices/lab_pin.sym} 1160 800 0 0 {name=lw143 lab=WENL[23]}
C {devices/lab_pin.sym} 1160 820 0 0 {name=lw144 lab=WENL[22]}
C {devices/lab_pin.sym} 1160 840 0 0 {name=lw145 lab=WENL[21]}
C {devices/lab_pin.sym} 1160 860 0 0 {name=lw146 lab=WENL[20]}
C {devices/lab_pin.sym} 1160 880 0 0 {name=lw147 lab=WENL[19]}
C {devices/lab_pin.sym} 1160 900 0 0 {name=lw148 lab=WENL[18]}
C {devices/lab_pin.sym} 1160 920 0 0 {name=lw149 lab=WENL[17]}
C {devices/lab_pin.sym} 1160 940 0 0 {name=lw150 lab=WENL[16]}
C {devices/lab_pin.sym} 1160 960 0 0 {name=lw151 lab=WENL[15]}
C {devices/lab_pin.sym} 1160 980 0 0 {name=lw152 lab=WENL[14]}
C {devices/lab_pin.sym} 1160 1000 0 0 {name=lw153 lab=WENL[13]}
C {devices/lab_pin.sym} 1160 1020 0 0 {name=lw154 lab=WENL[12]}
C {devices/lab_pin.sym} 1160 1040 0 0 {name=lw155 lab=WENL[11]}
C {devices/lab_pin.sym} 1160 1060 0 0 {name=lw156 lab=WENL[10]}
C {devices/lab_pin.sym} 1160 1080 0 0 {name=lw157 lab=WENL[9]}
C {devices/lab_pin.sym} 1160 1100 0 0 {name=lw158 lab=WENL[8]}
C {devices/lab_pin.sym} 1160 1120 0 0 {name=lw159 lab=WENL[7]}
C {devices/lab_pin.sym} 1160 1140 0 0 {name=lw160 lab=WENL[6]}
C {devices/lab_pin.sym} 1160 1160 0 0 {name=lw161 lab=WENL[5]}
C {devices/lab_pin.sym} 1160 1180 0 0 {name=lw162 lab=WENL[4]}
C {devices/lab_pin.sym} 1160 1200 0 0 {name=lw163 lab=WENL[3]}
C {devices/lab_pin.sym} 1160 1220 0 0 {name=lw164 lab=WENL[2]}
C {devices/lab_pin.sym} 1160 1240 0 0 {name=lw165 lab=WENL[1]}
C {devices/lab_pin.sym} 1160 1260 0 0 {name=lw166 lab=WENL[0]}
C {devices/lab_pin.sym} 1160 1280 0 0 {name=lw167 lab=VDD}
C {devices/lab_pin.sym} 1160 1300 0 0 {name=lw168 lab=VSS}
C {macro/bit_slice.sym} 0 2880 0 0 {name=XS[31:0]}
C {devices/lab_pin.sym} -40 1480 0 0 {name=lw169 lab=PRE_B}
C {devices/lab_pin.sym} -40 1500 0 0 {name=lw170 lab=SEL0}
C {devices/lab_pin.sym} -40 1520 0 0 {name=lw171 lab=SEL0B}
C {devices/lab_pin.sym} -40 1540 0 0 {name=lw172 lab=SEL1}
C {devices/lab_pin.sym} -40 1560 0 0 {name=lw173 lab=SEL1B}
C {devices/lab_pin.sym} -40 1580 0 0 {name=lw174 lab=SAE}
C {devices/lab_pin.sym} -40 1600 0 0 {name=lw175 lab=WE}
C {devices/lab_pin.sym} -40 1620 0 0 {name=lw176 lab=DL[31:0]}
C {devices/lab_pin.sym} -40 1640 0 0 {name=lw177 lab=WENL[31:0]}
C {devices/lab_pin.sym} -40 1660 0 0 {name=lw178 lab=WL[127]}
C {devices/lab_pin.sym} -40 1680 0 0 {name=lw179 lab=WL[126]}
C {devices/lab_pin.sym} -40 1700 0 0 {name=lw180 lab=WL[125]}
C {devices/lab_pin.sym} -40 1720 0 0 {name=lw181 lab=WL[124]}
C {devices/lab_pin.sym} -40 1740 0 0 {name=lw182 lab=WL[123]}
C {devices/lab_pin.sym} -40 1760 0 0 {name=lw183 lab=WL[122]}
C {devices/lab_pin.sym} -40 1780 0 0 {name=lw184 lab=WL[121]}
C {devices/lab_pin.sym} -40 1800 0 0 {name=lw185 lab=WL[120]}
C {devices/lab_pin.sym} -40 1820 0 0 {name=lw186 lab=WL[119]}
C {devices/lab_pin.sym} -40 1840 0 0 {name=lw187 lab=WL[118]}
C {devices/lab_pin.sym} -40 1860 0 0 {name=lw188 lab=WL[117]}
C {devices/lab_pin.sym} -40 1880 0 0 {name=lw189 lab=WL[116]}
C {devices/lab_pin.sym} -40 1900 0 0 {name=lw190 lab=WL[115]}
C {devices/lab_pin.sym} -40 1920 0 0 {name=lw191 lab=WL[114]}
C {devices/lab_pin.sym} -40 1940 0 0 {name=lw192 lab=WL[113]}
C {devices/lab_pin.sym} -40 1960 0 0 {name=lw193 lab=WL[112]}
C {devices/lab_pin.sym} -40 1980 0 0 {name=lw194 lab=WL[111]}
C {devices/lab_pin.sym} -40 2000 0 0 {name=lw195 lab=WL[110]}
C {devices/lab_pin.sym} -40 2020 0 0 {name=lw196 lab=WL[109]}
C {devices/lab_pin.sym} -40 2040 0 0 {name=lw197 lab=WL[108]}
C {devices/lab_pin.sym} -40 2060 0 0 {name=lw198 lab=WL[107]}
C {devices/lab_pin.sym} -40 2080 0 0 {name=lw199 lab=WL[106]}
C {devices/lab_pin.sym} -40 2100 0 0 {name=lw200 lab=WL[105]}
C {devices/lab_pin.sym} -40 2120 0 0 {name=lw201 lab=WL[104]}
C {devices/lab_pin.sym} -40 2140 0 0 {name=lw202 lab=WL[103]}
C {devices/lab_pin.sym} -40 2160 0 0 {name=lw203 lab=WL[102]}
C {devices/lab_pin.sym} -40 2180 0 0 {name=lw204 lab=WL[101]}
C {devices/lab_pin.sym} -40 2200 0 0 {name=lw205 lab=WL[100]}
C {devices/lab_pin.sym} -40 2220 0 0 {name=lw206 lab=WL[99]}
C {devices/lab_pin.sym} -40 2240 0 0 {name=lw207 lab=WL[98]}
C {devices/lab_pin.sym} -40 2260 0 0 {name=lw208 lab=WL[97]}
C {devices/lab_pin.sym} -40 2280 0 0 {name=lw209 lab=WL[96]}
C {devices/lab_pin.sym} -40 2300 0 0 {name=lw210 lab=WL[95]}
C {devices/lab_pin.sym} -40 2320 0 0 {name=lw211 lab=WL[94]}
C {devices/lab_pin.sym} -40 2340 0 0 {name=lw212 lab=WL[93]}
C {devices/lab_pin.sym} -40 2360 0 0 {name=lw213 lab=WL[92]}
C {devices/lab_pin.sym} -40 2380 0 0 {name=lw214 lab=WL[91]}
C {devices/lab_pin.sym} -40 2400 0 0 {name=lw215 lab=WL[90]}
C {devices/lab_pin.sym} -40 2420 0 0 {name=lw216 lab=WL[89]}
C {devices/lab_pin.sym} -40 2440 0 0 {name=lw217 lab=WL[88]}
C {devices/lab_pin.sym} -40 2460 0 0 {name=lw218 lab=WL[87]}
C {devices/lab_pin.sym} -40 2480 0 0 {name=lw219 lab=WL[86]}
C {devices/lab_pin.sym} -40 2500 0 0 {name=lw220 lab=WL[85]}
C {devices/lab_pin.sym} -40 2520 0 0 {name=lw221 lab=WL[84]}
C {devices/lab_pin.sym} -40 2540 0 0 {name=lw222 lab=WL[83]}
C {devices/lab_pin.sym} -40 2560 0 0 {name=lw223 lab=WL[82]}
C {devices/lab_pin.sym} -40 2580 0 0 {name=lw224 lab=WL[81]}
C {devices/lab_pin.sym} -40 2600 0 0 {name=lw225 lab=WL[80]}
C {devices/lab_pin.sym} -40 2620 0 0 {name=lw226 lab=WL[79]}
C {devices/lab_pin.sym} -40 2640 0 0 {name=lw227 lab=WL[78]}
C {devices/lab_pin.sym} -40 2660 0 0 {name=lw228 lab=WL[77]}
C {devices/lab_pin.sym} -40 2680 0 0 {name=lw229 lab=WL[76]}
C {devices/lab_pin.sym} -40 2700 0 0 {name=lw230 lab=WL[75]}
C {devices/lab_pin.sym} -40 2720 0 0 {name=lw231 lab=WL[74]}
C {devices/lab_pin.sym} -40 2740 0 0 {name=lw232 lab=WL[73]}
C {devices/lab_pin.sym} -40 2760 0 0 {name=lw233 lab=WL[72]}
C {devices/lab_pin.sym} -40 2780 0 0 {name=lw234 lab=WL[71]}
C {devices/lab_pin.sym} -40 2800 0 0 {name=lw235 lab=WL[70]}
C {devices/lab_pin.sym} -40 2820 0 0 {name=lw236 lab=WL[69]}
C {devices/lab_pin.sym} -40 2840 0 0 {name=lw237 lab=WL[68]}
C {devices/lab_pin.sym} -40 2860 0 0 {name=lw238 lab=WL[67]}
C {devices/lab_pin.sym} -40 2880 0 0 {name=lw239 lab=WL[66]}
C {devices/lab_pin.sym} -40 2900 0 0 {name=lw240 lab=WL[65]}
C {devices/lab_pin.sym} -40 2920 0 0 {name=lw241 lab=WL[64]}
C {devices/lab_pin.sym} -40 2940 0 0 {name=lw242 lab=WL[63]}
C {devices/lab_pin.sym} -40 2960 0 0 {name=lw243 lab=WL[62]}
C {devices/lab_pin.sym} -40 2980 0 0 {name=lw244 lab=WL[61]}
C {devices/lab_pin.sym} -40 3000 0 0 {name=lw245 lab=WL[60]}
C {devices/lab_pin.sym} -40 3020 0 0 {name=lw246 lab=WL[59]}
C {devices/lab_pin.sym} -40 3040 0 0 {name=lw247 lab=WL[58]}
C {devices/lab_pin.sym} -40 3060 0 0 {name=lw248 lab=WL[57]}
C {devices/lab_pin.sym} -40 3080 0 0 {name=lw249 lab=WL[56]}
C {devices/lab_pin.sym} -40 3100 0 0 {name=lw250 lab=WL[55]}
C {devices/lab_pin.sym} -40 3120 0 0 {name=lw251 lab=WL[54]}
C {devices/lab_pin.sym} -40 3140 0 0 {name=lw252 lab=WL[53]}
C {devices/lab_pin.sym} -40 3160 0 0 {name=lw253 lab=WL[52]}
C {devices/lab_pin.sym} -40 3180 0 0 {name=lw254 lab=WL[51]}
C {devices/lab_pin.sym} -40 3200 0 0 {name=lw255 lab=WL[50]}
C {devices/lab_pin.sym} -40 3220 0 0 {name=lw256 lab=WL[49]}
C {devices/lab_pin.sym} -40 3240 0 0 {name=lw257 lab=WL[48]}
C {devices/lab_pin.sym} -40 3260 0 0 {name=lw258 lab=WL[47]}
C {devices/lab_pin.sym} -40 3280 0 0 {name=lw259 lab=WL[46]}
C {devices/lab_pin.sym} -40 3300 0 0 {name=lw260 lab=WL[45]}
C {devices/lab_pin.sym} -40 3320 0 0 {name=lw261 lab=WL[44]}
C {devices/lab_pin.sym} -40 3340 0 0 {name=lw262 lab=WL[43]}
C {devices/lab_pin.sym} -40 3360 0 0 {name=lw263 lab=WL[42]}
C {devices/lab_pin.sym} -40 3380 0 0 {name=lw264 lab=WL[41]}
C {devices/lab_pin.sym} -40 3400 0 0 {name=lw265 lab=WL[40]}
C {devices/lab_pin.sym} -40 3420 0 0 {name=lw266 lab=WL[39]}
C {devices/lab_pin.sym} -40 3440 0 0 {name=lw267 lab=WL[38]}
C {devices/lab_pin.sym} -40 3460 0 0 {name=lw268 lab=WL[37]}
C {devices/lab_pin.sym} -40 3480 0 0 {name=lw269 lab=WL[36]}
C {devices/lab_pin.sym} -40 3500 0 0 {name=lw270 lab=WL[35]}
C {devices/lab_pin.sym} -40 3520 0 0 {name=lw271 lab=WL[34]}
C {devices/lab_pin.sym} -40 3540 0 0 {name=lw272 lab=WL[33]}
C {devices/lab_pin.sym} -40 3560 0 0 {name=lw273 lab=WL[32]}
C {devices/lab_pin.sym} -40 3580 0 0 {name=lw274 lab=WL[31]}
C {devices/lab_pin.sym} -40 3600 0 0 {name=lw275 lab=WL[30]}
C {devices/lab_pin.sym} -40 3620 0 0 {name=lw276 lab=WL[29]}
C {devices/lab_pin.sym} -40 3640 0 0 {name=lw277 lab=WL[28]}
C {devices/lab_pin.sym} -40 3660 0 0 {name=lw278 lab=WL[27]}
C {devices/lab_pin.sym} -40 3680 0 0 {name=lw279 lab=WL[26]}
C {devices/lab_pin.sym} -40 3700 0 0 {name=lw280 lab=WL[25]}
C {devices/lab_pin.sym} -40 3720 0 0 {name=lw281 lab=WL[24]}
C {devices/lab_pin.sym} -40 3740 0 0 {name=lw282 lab=WL[23]}
C {devices/lab_pin.sym} -40 3760 0 0 {name=lw283 lab=WL[22]}
C {devices/lab_pin.sym} -40 3780 0 0 {name=lw284 lab=WL[21]}
C {devices/lab_pin.sym} -40 3800 0 0 {name=lw285 lab=WL[20]}
C {devices/lab_pin.sym} -40 3820 0 0 {name=lw286 lab=WL[19]}
C {devices/lab_pin.sym} -40 3840 0 0 {name=lw287 lab=WL[18]}
C {devices/lab_pin.sym} -40 3860 0 0 {name=lw288 lab=WL[17]}
C {devices/lab_pin.sym} -40 3880 0 0 {name=lw289 lab=WL[16]}
C {devices/lab_pin.sym} -40 3900 0 0 {name=lw290 lab=WL[15]}
C {devices/lab_pin.sym} -40 3920 0 0 {name=lw291 lab=WL[14]}
C {devices/lab_pin.sym} -40 3940 0 0 {name=lw292 lab=WL[13]}
C {devices/lab_pin.sym} -40 3960 0 0 {name=lw293 lab=WL[12]}
C {devices/lab_pin.sym} -40 3980 0 0 {name=lw294 lab=WL[11]}
C {devices/lab_pin.sym} -40 4000 0 0 {name=lw295 lab=WL[10]}
C {devices/lab_pin.sym} -40 4020 0 0 {name=lw296 lab=WL[9]}
C {devices/lab_pin.sym} -40 4040 0 0 {name=lw297 lab=WL[8]}
C {devices/lab_pin.sym} -40 4060 0 0 {name=lw298 lab=WL[7]}
C {devices/lab_pin.sym} -40 4080 0 0 {name=lw299 lab=WL[6]}
C {devices/lab_pin.sym} -40 4100 0 0 {name=lw300 lab=WL[5]}
C {devices/lab_pin.sym} -40 4120 0 0 {name=lw301 lab=WL[4]}
C {devices/lab_pin.sym} -40 4140 0 0 {name=lw302 lab=WL[3]}
C {devices/lab_pin.sym} -40 4160 0 0 {name=lw303 lab=WL[2]}
C {devices/lab_pin.sym} -40 4180 0 0 {name=lw304 lab=WL[1]}
C {devices/lab_pin.sym} -40 4200 0 0 {name=lw305 lab=WL[0]}
C {devices/lab_pin.sym} -40 4220 0 0 {name=lw306 lab=DOUT[31:0]}
C {devices/lab_pin.sym} -40 4240 0 0 {name=lw307 lab=DOUTB[31:0]}
C {devices/lab_pin.sym} -40 4260 0 0 {name=lw308 lab=VDD}
C {devices/lab_pin.sym} -40 4280 0 0 {name=lw309 lab=VSS}
C {latches/out_latch.sym} 400 2880 0 0 {name=XQL}
C {devices/lab_pin.sym} 360.0 2220.0 0 0 {name=l385 lab=SAE}
C {devices/lab_pin.sym} 360.0 2240.0 0 0 {name=l386 lab=DOUT[31]}
C {devices/lab_pin.sym} 360.0 2260.0 0 0 {name=l387 lab=DOUT[30]}
C {devices/lab_pin.sym} 360.0 2280.0 0 0 {name=l388 lab=DOUT[29]}
C {devices/lab_pin.sym} 360.0 2300.0 0 0 {name=l389 lab=DOUT[28]}
C {devices/lab_pin.sym} 360.0 2320.0 0 0 {name=l390 lab=DOUT[27]}
C {devices/lab_pin.sym} 360.0 2340.0 0 0 {name=l391 lab=DOUT[26]}
C {devices/lab_pin.sym} 360.0 2360.0 0 0 {name=l392 lab=DOUT[25]}
C {devices/lab_pin.sym} 360.0 2380.0 0 0 {name=l393 lab=DOUT[24]}
C {devices/lab_pin.sym} 360.0 2400.0 0 0 {name=l394 lab=DOUT[23]}
C {devices/lab_pin.sym} 360.0 2420.0 0 0 {name=l395 lab=DOUT[22]}
C {devices/lab_pin.sym} 360.0 2440.0 0 0 {name=l396 lab=DOUT[21]}
C {devices/lab_pin.sym} 360.0 2460.0 0 0 {name=l397 lab=DOUT[20]}
C {devices/lab_pin.sym} 360.0 2480.0 0 0 {name=l398 lab=DOUT[19]}
C {devices/lab_pin.sym} 360.0 2500.0 0 0 {name=l399 lab=DOUT[18]}
C {devices/lab_pin.sym} 360.0 2520.0 0 0 {name=l400 lab=DOUT[17]}
C {devices/lab_pin.sym} 360.0 2540.0 0 0 {name=l401 lab=DOUT[16]}
C {devices/lab_pin.sym} 360.0 2560.0 0 0 {name=l402 lab=DOUT[15]}
C {devices/lab_pin.sym} 360.0 2580.0 0 0 {name=l403 lab=DOUT[14]}
C {devices/lab_pin.sym} 360.0 2600.0 0 0 {name=l404 lab=DOUT[13]}
C {devices/lab_pin.sym} 360.0 2620.0 0 0 {name=l405 lab=DOUT[12]}
C {devices/lab_pin.sym} 360.0 2640.0 0 0 {name=l406 lab=DOUT[11]}
C {devices/lab_pin.sym} 360.0 2660.0 0 0 {name=l407 lab=DOUT[10]}
C {devices/lab_pin.sym} 360.0 2680.0 0 0 {name=l408 lab=DOUT[9]}
C {devices/lab_pin.sym} 360.0 2700.0 0 0 {name=l409 lab=DOUT[8]}
C {devices/lab_pin.sym} 360.0 2720.0 0 0 {name=l410 lab=DOUT[7]}
C {devices/lab_pin.sym} 360.0 2740.0 0 0 {name=l411 lab=DOUT[6]}
C {devices/lab_pin.sym} 360.0 2760.0 0 0 {name=l412 lab=DOUT[5]}
C {devices/lab_pin.sym} 360.0 2780.0 0 0 {name=l413 lab=DOUT[4]}
C {devices/lab_pin.sym} 360.0 2800.0 0 0 {name=l414 lab=DOUT[3]}
C {devices/lab_pin.sym} 360.0 2820.0 0 0 {name=l415 lab=DOUT[2]}
C {devices/lab_pin.sym} 360.0 2840.0 0 0 {name=l416 lab=DOUT[1]}
C {devices/lab_pin.sym} 360.0 2860.0 0 0 {name=l417 lab=DOUT[0]}
C {devices/lab_pin.sym} 360.0 2880.0 0 0 {name=l418 lab=Q[31]}
C {devices/lab_pin.sym} 360.0 2900.0 0 0 {name=l419 lab=Q[30]}
C {devices/lab_pin.sym} 360.0 2920.0 0 0 {name=l420 lab=Q[29]}
C {devices/lab_pin.sym} 360.0 2940.0 0 0 {name=l421 lab=Q[28]}
C {devices/lab_pin.sym} 360.0 2960.0 0 0 {name=l422 lab=Q[27]}
C {devices/lab_pin.sym} 360.0 2980.0 0 0 {name=l423 lab=Q[26]}
C {devices/lab_pin.sym} 360.0 3000.0 0 0 {name=l424 lab=Q[25]}
C {devices/lab_pin.sym} 360.0 3020.0 0 0 {name=l425 lab=Q[24]}
C {devices/lab_pin.sym} 360.0 3040.0 0 0 {name=l426 lab=Q[23]}
C {devices/lab_pin.sym} 360.0 3060.0 0 0 {name=l427 lab=Q[22]}
C {devices/lab_pin.sym} 360.0 3080.0 0 0 {name=l428 lab=Q[21]}
C {devices/lab_pin.sym} 360.0 3100.0 0 0 {name=l429 lab=Q[20]}
C {devices/lab_pin.sym} 360.0 3120.0 0 0 {name=l430 lab=Q[19]}
C {devices/lab_pin.sym} 360.0 3140.0 0 0 {name=l431 lab=Q[18]}
C {devices/lab_pin.sym} 360.0 3160.0 0 0 {name=l432 lab=Q[17]}
C {devices/lab_pin.sym} 360.0 3180.0 0 0 {name=l433 lab=Q[16]}
C {devices/lab_pin.sym} 360.0 3200.0 0 0 {name=l434 lab=Q[15]}
C {devices/lab_pin.sym} 360.0 3220.0 0 0 {name=l435 lab=Q[14]}
C {devices/lab_pin.sym} 360.0 3240.0 0 0 {name=l436 lab=Q[13]}
C {devices/lab_pin.sym} 360.0 3260.0 0 0 {name=l437 lab=Q[12]}
C {devices/lab_pin.sym} 360.0 3280.0 0 0 {name=l438 lab=Q[11]}
C {devices/lab_pin.sym} 360.0 3300.0 0 0 {name=l439 lab=Q[10]}
C {devices/lab_pin.sym} 360.0 3320.0 0 0 {name=l440 lab=Q[9]}
C {devices/lab_pin.sym} 360.0 3340.0 0 0 {name=l441 lab=Q[8]}
C {devices/lab_pin.sym} 360.0 3360.0 0 0 {name=l442 lab=Q[7]}
C {devices/lab_pin.sym} 360.0 3380.0 0 0 {name=l443 lab=Q[6]}
C {devices/lab_pin.sym} 360.0 3400.0 0 0 {name=l444 lab=Q[5]}
C {devices/lab_pin.sym} 360.0 3420.0 0 0 {name=l445 lab=Q[4]}
C {devices/lab_pin.sym} 360.0 3440.0 0 0 {name=l446 lab=Q[3]}
C {devices/lab_pin.sym} 360.0 3460.0 0 0 {name=l447 lab=Q[2]}
C {devices/lab_pin.sym} 360.0 3480.0 0 0 {name=l448 lab=Q[1]}
C {devices/lab_pin.sym} 360.0 3500.0 0 0 {name=l449 lab=Q[0]}
C {devices/lab_pin.sym} 360.0 3520.0 0 0 {name=l450 lab=VDD}
C {devices/lab_pin.sym} 360.0 3540.0 0 0 {name=l451 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=pw310 lab=A[7]}
C {devices/ipin.sym} -900 -260 0 0 {name=pw311 lab=A[6]}
C {devices/ipin.sym} -900 -220 0 0 {name=pw312 lab=A[5]}
C {devices/ipin.sym} -900 -180 0 0 {name=pw313 lab=A[4]}
C {devices/ipin.sym} -900 -140 0 0 {name=pw314 lab=A[3]}
C {devices/ipin.sym} -900 -100 0 0 {name=pw315 lab=A[2]}
C {devices/ipin.sym} -900 -60 0 0 {name=pw316 lab=A[1]}
C {devices/ipin.sym} -900 -20 0 0 {name=pw317 lab=A[0]}
C {devices/ipin.sym} -900 20 0 0 {name=pw318 lab=CEN}
C {devices/ipin.sym} -900 60 0 0 {name=pw319 lab=CLK}
C {devices/ipin.sym} -900 100 0 0 {name=pw320 lab=D[31]}
C {devices/ipin.sym} -900 140 0 0 {name=pw321 lab=D[30]}
C {devices/ipin.sym} -900 180 0 0 {name=pw322 lab=D[29]}
C {devices/ipin.sym} -900 220 0 0 {name=pw323 lab=D[28]}
C {devices/ipin.sym} -900 260 0 0 {name=pw324 lab=D[27]}
C {devices/ipin.sym} -900 300 0 0 {name=pw325 lab=D[26]}
C {devices/ipin.sym} -900 340 0 0 {name=pw326 lab=D[25]}
C {devices/ipin.sym} -900 380 0 0 {name=pw327 lab=D[24]}
C {devices/ipin.sym} -900 420 0 0 {name=pw328 lab=D[23]}
C {devices/ipin.sym} -900 460 0 0 {name=pw329 lab=D[22]}
C {devices/ipin.sym} -900 500 0 0 {name=pw330 lab=D[21]}
C {devices/ipin.sym} -900 540 0 0 {name=pw331 lab=D[20]}
C {devices/ipin.sym} -900 580 0 0 {name=pw332 lab=D[19]}
C {devices/ipin.sym} -900 620 0 0 {name=pw333 lab=D[18]}
C {devices/ipin.sym} -900 660 0 0 {name=pw334 lab=D[17]}
C {devices/ipin.sym} -900 700 0 0 {name=pw335 lab=D[16]}
C {devices/ipin.sym} -900 740 0 0 {name=pw336 lab=D[15]}
C {devices/ipin.sym} -900 780 0 0 {name=pw337 lab=D[14]}
C {devices/ipin.sym} -900 820 0 0 {name=pw338 lab=D[13]}
C {devices/ipin.sym} -900 860 0 0 {name=pw339 lab=D[12]}
C {devices/ipin.sym} -900 900 0 0 {name=pw340 lab=D[11]}
C {devices/ipin.sym} -900 940 0 0 {name=pw341 lab=D[10]}
C {devices/ipin.sym} -900 980 0 0 {name=pw342 lab=D[9]}
C {devices/ipin.sym} -900 1020 0 0 {name=pw343 lab=D[8]}
C {devices/ipin.sym} -900 1060 0 0 {name=pw344 lab=D[7]}
C {devices/ipin.sym} -900 1100 0 0 {name=pw345 lab=D[6]}
C {devices/ipin.sym} -900 1140 0 0 {name=pw346 lab=D[5]}
C {devices/ipin.sym} -900 1180 0 0 {name=pw347 lab=D[4]}
C {devices/ipin.sym} -900 1220 0 0 {name=pw348 lab=D[3]}
C {devices/ipin.sym} -900 1260 0 0 {name=pw349 lab=D[2]}
C {devices/ipin.sym} -900 1300 0 0 {name=pw350 lab=D[1]}
C {devices/ipin.sym} -900 1340 0 0 {name=pw351 lab=D[0]}
C {devices/opin.sym} -900 1380 0 0 {name=pw352 lab=Q[31]}
C {devices/opin.sym} -900 1420 0 0 {name=pw353 lab=Q[30]}
C {devices/opin.sym} -900 1460 0 0 {name=pw354 lab=Q[29]}
C {devices/opin.sym} -900 1500 0 0 {name=pw355 lab=Q[28]}
C {devices/opin.sym} -900 1540 0 0 {name=pw356 lab=Q[27]}
C {devices/opin.sym} -900 1580 0 0 {name=pw357 lab=Q[26]}
C {devices/opin.sym} -900 1620 0 0 {name=pw358 lab=Q[25]}
C {devices/opin.sym} -900 1660 0 0 {name=pw359 lab=Q[24]}
C {devices/opin.sym} -900 1700 0 0 {name=pw360 lab=Q[23]}
C {devices/opin.sym} -900 1740 0 0 {name=pw361 lab=Q[22]}
C {devices/opin.sym} -900 1780 0 0 {name=pw362 lab=Q[21]}
C {devices/opin.sym} -900 1820 0 0 {name=pw363 lab=Q[20]}
C {devices/opin.sym} -900 1860 0 0 {name=pw364 lab=Q[19]}
C {devices/opin.sym} -900 1900 0 0 {name=pw365 lab=Q[18]}
C {devices/opin.sym} -900 1940 0 0 {name=pw366 lab=Q[17]}
C {devices/opin.sym} -900 1980 0 0 {name=pw367 lab=Q[16]}
C {devices/opin.sym} -900 2020 0 0 {name=pw368 lab=Q[15]}
C {devices/opin.sym} -900 2060 0 0 {name=pw369 lab=Q[14]}
C {devices/opin.sym} -900 2100 0 0 {name=pw370 lab=Q[13]}
C {devices/opin.sym} -900 2140 0 0 {name=pw371 lab=Q[12]}
C {devices/opin.sym} -900 2180 0 0 {name=pw372 lab=Q[11]}
C {devices/opin.sym} -900 2220 0 0 {name=pw373 lab=Q[10]}
C {devices/opin.sym} -900 2260 0 0 {name=pw374 lab=Q[9]}
C {devices/opin.sym} -900 2300 0 0 {name=pw375 lab=Q[8]}
C {devices/opin.sym} -900 2340 0 0 {name=pw376 lab=Q[7]}
C {devices/opin.sym} -900 2380 0 0 {name=pw377 lab=Q[6]}
C {devices/opin.sym} -900 2420 0 0 {name=pw378 lab=Q[5]}
C {devices/opin.sym} -900 2460 0 0 {name=pw379 lab=Q[4]}
C {devices/opin.sym} -900 2500 0 0 {name=pw380 lab=Q[3]}
C {devices/opin.sym} -900 2540 0 0 {name=pw381 lab=Q[2]}
C {devices/opin.sym} -900 2580 0 0 {name=pw382 lab=Q[1]}
C {devices/opin.sym} -900 2620 0 0 {name=pw383 lab=Q[0]}
C {devices/ipin.sym} -900 2660 0 0 {name=pw384 lab=GWEN}
C {devices/ipin.sym} -900 2700 0 0 {name=pw385 lab=WEN[31]}
C {devices/ipin.sym} -900 2740 0 0 {name=pw386 lab=WEN[30]}
C {devices/ipin.sym} -900 2780 0 0 {name=pw387 lab=WEN[29]}
C {devices/ipin.sym} -900 2820 0 0 {name=pw388 lab=WEN[28]}
C {devices/ipin.sym} -900 2860 0 0 {name=pw389 lab=WEN[27]}
C {devices/ipin.sym} -900 2900 0 0 {name=pw390 lab=WEN[26]}
C {devices/ipin.sym} -900 2940 0 0 {name=pw391 lab=WEN[25]}
C {devices/ipin.sym} -900 2980 0 0 {name=pw392 lab=WEN[24]}
C {devices/ipin.sym} -900 3020 0 0 {name=pw393 lab=WEN[23]}
C {devices/ipin.sym} -900 3060 0 0 {name=pw394 lab=WEN[22]}
C {devices/ipin.sym} -900 3100 0 0 {name=pw395 lab=WEN[21]}
C {devices/ipin.sym} -900 3140 0 0 {name=pw396 lab=WEN[20]}
C {devices/ipin.sym} -900 3180 0 0 {name=pw397 lab=WEN[19]}
C {devices/ipin.sym} -900 3220 0 0 {name=pw398 lab=WEN[18]}
C {devices/ipin.sym} -900 3260 0 0 {name=pw399 lab=WEN[17]}
C {devices/ipin.sym} -900 3300 0 0 {name=pw400 lab=WEN[16]}
C {devices/ipin.sym} -900 3340 0 0 {name=pw401 lab=WEN[15]}
C {devices/ipin.sym} -900 3380 0 0 {name=pw402 lab=WEN[14]}
C {devices/ipin.sym} -900 3420 0 0 {name=pw403 lab=WEN[13]}
C {devices/ipin.sym} -900 3460 0 0 {name=pw404 lab=WEN[12]}
C {devices/ipin.sym} -900 3500 0 0 {name=pw405 lab=WEN[11]}
C {devices/ipin.sym} -900 3540 0 0 {name=pw406 lab=WEN[10]}
C {devices/ipin.sym} -900 3580 0 0 {name=pw407 lab=WEN[9]}
C {devices/ipin.sym} -900 3620 0 0 {name=pw408 lab=WEN[8]}
C {devices/ipin.sym} -900 3660 0 0 {name=pw409 lab=WEN[7]}
C {devices/ipin.sym} -900 3700 0 0 {name=pw410 lab=WEN[6]}
C {devices/ipin.sym} -900 3740 0 0 {name=pw411 lab=WEN[5]}
C {devices/ipin.sym} -900 3780 0 0 {name=pw412 lab=WEN[4]}
C {devices/ipin.sym} -900 3820 0 0 {name=pw413 lab=WEN[3]}
C {devices/ipin.sym} -900 3860 0 0 {name=pw414 lab=WEN[2]}
C {devices/ipin.sym} -900 3900 0 0 {name=pw415 lab=WEN[1]}
C {devices/ipin.sym} -900 3940 0 0 {name=pw416 lab=WEN[0]}
C {devices/iopin.sym} -900 3980 0 0 {name=pw417 lab=VDD}
C {devices/iopin.sym} -900 4020 0 0 {name=pw418 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* 256 x 32 SRAM macro (128 rows x 64 columns, mux 2): A[0] selects the column, A[7:1] the row; one supply rail VDD/VSS"}
