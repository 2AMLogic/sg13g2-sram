v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
C {macro/bl_pair.sym} 0 0 0 0 {name=XA0}
C {devices/lab_pin.sym} -40.0 -1310.0 0 0 {name=l0 lab=WL[127]}
C {devices/lab_pin.sym} -40.0 -1290.0 0 0 {name=l1 lab=WL[126]}
C {devices/lab_pin.sym} -40.0 -1270.0 0 0 {name=l2 lab=WL[125]}
C {devices/lab_pin.sym} -40.0 -1250.0 0 0 {name=l3 lab=WL[124]}
C {devices/lab_pin.sym} -40.0 -1230.0 0 0 {name=l4 lab=WL[123]}
C {devices/lab_pin.sym} -40.0 -1210.0 0 0 {name=l5 lab=WL[122]}
C {devices/lab_pin.sym} -40.0 -1190.0 0 0 {name=l6 lab=WL[121]}
C {devices/lab_pin.sym} -40.0 -1170.0 0 0 {name=l7 lab=WL[120]}
C {devices/lab_pin.sym} -40.0 -1150.0 0 0 {name=l8 lab=WL[119]}
C {devices/lab_pin.sym} -40.0 -1130.0 0 0 {name=l9 lab=WL[118]}
C {devices/lab_pin.sym} -40.0 -1110.0 0 0 {name=l10 lab=WL[117]}
C {devices/lab_pin.sym} -40.0 -1090.0 0 0 {name=l11 lab=WL[116]}
C {devices/lab_pin.sym} -40.0 -1070.0 0 0 {name=l12 lab=WL[115]}
C {devices/lab_pin.sym} -40.0 -1050.0 0 0 {name=l13 lab=WL[114]}
C {devices/lab_pin.sym} -40.0 -1030.0 0 0 {name=l14 lab=WL[113]}
C {devices/lab_pin.sym} -40.0 -1010.0 0 0 {name=l15 lab=WL[112]}
C {devices/lab_pin.sym} -40.0 -990.0 0 0 {name=l16 lab=WL[111]}
C {devices/lab_pin.sym} -40.0 -970.0 0 0 {name=l17 lab=WL[110]}
C {devices/lab_pin.sym} -40.0 -950.0 0 0 {name=l18 lab=WL[109]}
C {devices/lab_pin.sym} -40.0 -930.0 0 0 {name=l19 lab=WL[108]}
C {devices/lab_pin.sym} -40.0 -910.0 0 0 {name=l20 lab=WL[107]}
C {devices/lab_pin.sym} -40.0 -890.0 0 0 {name=l21 lab=WL[106]}
C {devices/lab_pin.sym} -40.0 -870.0 0 0 {name=l22 lab=WL[105]}
C {devices/lab_pin.sym} -40.0 -850.0 0 0 {name=l23 lab=WL[104]}
C {devices/lab_pin.sym} -40.0 -830.0 0 0 {name=l24 lab=WL[103]}
C {devices/lab_pin.sym} -40.0 -810.0 0 0 {name=l25 lab=WL[102]}
C {devices/lab_pin.sym} -40.0 -790.0 0 0 {name=l26 lab=WL[101]}
C {devices/lab_pin.sym} -40.0 -770.0 0 0 {name=l27 lab=WL[100]}
C {devices/lab_pin.sym} -40.0 -750.0 0 0 {name=l28 lab=WL[99]}
C {devices/lab_pin.sym} -40.0 -730.0 0 0 {name=l29 lab=WL[98]}
C {devices/lab_pin.sym} -40.0 -710.0 0 0 {name=l30 lab=WL[97]}
C {devices/lab_pin.sym} -40.0 -690.0 0 0 {name=l31 lab=WL[96]}
C {devices/lab_pin.sym} -40.0 -670.0 0 0 {name=l32 lab=WL[95]}
C {devices/lab_pin.sym} -40.0 -650.0 0 0 {name=l33 lab=WL[94]}
C {devices/lab_pin.sym} -40.0 -630.0 0 0 {name=l34 lab=WL[93]}
C {devices/lab_pin.sym} -40.0 -610.0 0 0 {name=l35 lab=WL[92]}
C {devices/lab_pin.sym} -40.0 -590.0 0 0 {name=l36 lab=WL[91]}
C {devices/lab_pin.sym} -40.0 -570.0 0 0 {name=l37 lab=WL[90]}
C {devices/lab_pin.sym} -40.0 -550.0 0 0 {name=l38 lab=WL[89]}
C {devices/lab_pin.sym} -40.0 -530.0 0 0 {name=l39 lab=WL[88]}
C {devices/lab_pin.sym} -40.0 -510.0 0 0 {name=l40 lab=WL[87]}
C {devices/lab_pin.sym} -40.0 -490.0 0 0 {name=l41 lab=WL[86]}
C {devices/lab_pin.sym} -40.0 -470.0 0 0 {name=l42 lab=WL[85]}
C {devices/lab_pin.sym} -40.0 -450.0 0 0 {name=l43 lab=WL[84]}
C {devices/lab_pin.sym} -40.0 -430.0 0 0 {name=l44 lab=WL[83]}
C {devices/lab_pin.sym} -40.0 -410.0 0 0 {name=l45 lab=WL[82]}
C {devices/lab_pin.sym} -40.0 -390.0 0 0 {name=l46 lab=WL[81]}
C {devices/lab_pin.sym} -40.0 -370.0 0 0 {name=l47 lab=WL[80]}
C {devices/lab_pin.sym} -40.0 -350.0 0 0 {name=l48 lab=WL[79]}
C {devices/lab_pin.sym} -40.0 -330.0 0 0 {name=l49 lab=WL[78]}
C {devices/lab_pin.sym} -40.0 -310.0 0 0 {name=l50 lab=WL[77]}
C {devices/lab_pin.sym} -40.0 -290.0 0 0 {name=l51 lab=WL[76]}
C {devices/lab_pin.sym} -40.0 -270.0 0 0 {name=l52 lab=WL[75]}
C {devices/lab_pin.sym} -40.0 -250.0 0 0 {name=l53 lab=WL[74]}
C {devices/lab_pin.sym} -40.0 -230.0 0 0 {name=l54 lab=WL[73]}
C {devices/lab_pin.sym} -40.0 -210.0 0 0 {name=l55 lab=WL[72]}
C {devices/lab_pin.sym} -40.0 -190.0 0 0 {name=l56 lab=WL[71]}
C {devices/lab_pin.sym} -40.0 -170.0 0 0 {name=l57 lab=WL[70]}
C {devices/lab_pin.sym} -40.0 -150.0 0 0 {name=l58 lab=WL[69]}
C {devices/lab_pin.sym} -40.0 -130.0 0 0 {name=l59 lab=WL[68]}
C {devices/lab_pin.sym} -40.0 -110.0 0 0 {name=l60 lab=WL[67]}
C {devices/lab_pin.sym} -40.0 -90.0 0 0 {name=l61 lab=WL[66]}
C {devices/lab_pin.sym} -40.0 -70.0 0 0 {name=l62 lab=WL[65]}
C {devices/lab_pin.sym} -40.0 -50.0 0 0 {name=l63 lab=WL[64]}
C {devices/lab_pin.sym} -40.0 -30.0 0 0 {name=l64 lab=WL[63]}
C {devices/lab_pin.sym} -40.0 -10.0 0 0 {name=l65 lab=WL[62]}
C {devices/lab_pin.sym} -40.0 10.0 0 0 {name=l66 lab=WL[61]}
C {devices/lab_pin.sym} -40.0 30.0 0 0 {name=l67 lab=WL[60]}
C {devices/lab_pin.sym} -40.0 50.0 0 0 {name=l68 lab=WL[59]}
C {devices/lab_pin.sym} -40.0 70.0 0 0 {name=l69 lab=WL[58]}
C {devices/lab_pin.sym} -40.0 90.0 0 0 {name=l70 lab=WL[57]}
C {devices/lab_pin.sym} -40.0 110.0 0 0 {name=l71 lab=WL[56]}
C {devices/lab_pin.sym} -40.0 130.0 0 0 {name=l72 lab=WL[55]}
C {devices/lab_pin.sym} -40.0 150.0 0 0 {name=l73 lab=WL[54]}
C {devices/lab_pin.sym} -40.0 170.0 0 0 {name=l74 lab=WL[53]}
C {devices/lab_pin.sym} -40.0 190.0 0 0 {name=l75 lab=WL[52]}
C {devices/lab_pin.sym} -40.0 210.0 0 0 {name=l76 lab=WL[51]}
C {devices/lab_pin.sym} -40.0 230.0 0 0 {name=l77 lab=WL[50]}
C {devices/lab_pin.sym} -40.0 250.0 0 0 {name=l78 lab=WL[49]}
C {devices/lab_pin.sym} -40.0 270.0 0 0 {name=l79 lab=WL[48]}
C {devices/lab_pin.sym} -40.0 290.0 0 0 {name=l80 lab=WL[47]}
C {devices/lab_pin.sym} -40.0 310.0 0 0 {name=l81 lab=WL[46]}
C {devices/lab_pin.sym} -40.0 330.0 0 0 {name=l82 lab=WL[45]}
C {devices/lab_pin.sym} -40.0 350.0 0 0 {name=l83 lab=WL[44]}
C {devices/lab_pin.sym} -40.0 370.0 0 0 {name=l84 lab=WL[43]}
C {devices/lab_pin.sym} -40.0 390.0 0 0 {name=l85 lab=WL[42]}
C {devices/lab_pin.sym} -40.0 410.0 0 0 {name=l86 lab=WL[41]}
C {devices/lab_pin.sym} -40.0 430.0 0 0 {name=l87 lab=WL[40]}
C {devices/lab_pin.sym} -40.0 450.0 0 0 {name=l88 lab=WL[39]}
C {devices/lab_pin.sym} -40.0 470.0 0 0 {name=l89 lab=WL[38]}
C {devices/lab_pin.sym} -40.0 490.0 0 0 {name=l90 lab=WL[37]}
C {devices/lab_pin.sym} -40.0 510.0 0 0 {name=l91 lab=WL[36]}
C {devices/lab_pin.sym} -40.0 530.0 0 0 {name=l92 lab=WL[35]}
C {devices/lab_pin.sym} -40.0 550.0 0 0 {name=l93 lab=WL[34]}
C {devices/lab_pin.sym} -40.0 570.0 0 0 {name=l94 lab=WL[33]}
C {devices/lab_pin.sym} -40.0 590.0 0 0 {name=l95 lab=WL[32]}
C {devices/lab_pin.sym} -40.0 610.0 0 0 {name=l96 lab=WL[31]}
C {devices/lab_pin.sym} -40.0 630.0 0 0 {name=l97 lab=WL[30]}
C {devices/lab_pin.sym} -40.0 650.0 0 0 {name=l98 lab=WL[29]}
C {devices/lab_pin.sym} -40.0 670.0 0 0 {name=l99 lab=WL[28]}
C {devices/lab_pin.sym} -40.0 690.0 0 0 {name=l100 lab=WL[27]}
C {devices/lab_pin.sym} -40.0 710.0 0 0 {name=l101 lab=WL[26]}
C {devices/lab_pin.sym} -40.0 730.0 0 0 {name=l102 lab=WL[25]}
C {devices/lab_pin.sym} -40.0 750.0 0 0 {name=l103 lab=WL[24]}
C {devices/lab_pin.sym} -40.0 770.0 0 0 {name=l104 lab=WL[23]}
C {devices/lab_pin.sym} -40.0 790.0 0 0 {name=l105 lab=WL[22]}
C {devices/lab_pin.sym} -40.0 810.0 0 0 {name=l106 lab=WL[21]}
C {devices/lab_pin.sym} -40.0 830.0 0 0 {name=l107 lab=WL[20]}
C {devices/lab_pin.sym} -40.0 850.0 0 0 {name=l108 lab=WL[19]}
C {devices/lab_pin.sym} -40.0 870.0 0 0 {name=l109 lab=WL[18]}
C {devices/lab_pin.sym} -40.0 890.0 0 0 {name=l110 lab=WL[17]}
C {devices/lab_pin.sym} -40.0 910.0 0 0 {name=l111 lab=WL[16]}
C {devices/lab_pin.sym} -40.0 930.0 0 0 {name=l112 lab=WL[15]}
C {devices/lab_pin.sym} -40.0 950.0 0 0 {name=l113 lab=WL[14]}
C {devices/lab_pin.sym} -40.0 970.0 0 0 {name=l114 lab=WL[13]}
C {devices/lab_pin.sym} -40.0 990.0 0 0 {name=l115 lab=WL[12]}
C {devices/lab_pin.sym} -40.0 1010.0 0 0 {name=l116 lab=WL[11]}
C {devices/lab_pin.sym} -40.0 1030.0 0 0 {name=l117 lab=WL[10]}
C {devices/lab_pin.sym} -40.0 1050.0 0 0 {name=l118 lab=WL[9]}
C {devices/lab_pin.sym} -40.0 1070.0 0 0 {name=l119 lab=WL[8]}
C {devices/lab_pin.sym} -40.0 1090.0 0 0 {name=l120 lab=WL[7]}
C {devices/lab_pin.sym} -40.0 1110.0 0 0 {name=l121 lab=WL[6]}
C {devices/lab_pin.sym} -40.0 1130.0 0 0 {name=l122 lab=WL[5]}
C {devices/lab_pin.sym} -40.0 1150.0 0 0 {name=l123 lab=WL[4]}
C {devices/lab_pin.sym} -40.0 1170.0 0 0 {name=l124 lab=WL[3]}
C {devices/lab_pin.sym} -40.0 1190.0 0 0 {name=l125 lab=WL[2]}
C {devices/lab_pin.sym} -40.0 1210.0 0 0 {name=l126 lab=WL[1]}
C {devices/lab_pin.sym} -40.0 1230.0 0 0 {name=l127 lab=WL[0]}
C {devices/lab_pin.sym} -40.0 1250.0 0 0 {name=l128 lab=BL0}
C {devices/lab_pin.sym} -40.0 1270.0 0 0 {name=l129 lab=BLB0}
C {devices/lab_pin.sym} -40.0 1290.0 0 0 {name=l130 lab=VDD}
C {devices/lab_pin.sym} -40.0 1310.0 0 0 {name=l131 lab=VSS}
C {macro/bl_pair.sym} 400 0 0 0 {name=XA1}
C {devices/lab_pin.sym} 360.0 -1310.0 0 0 {name=l132 lab=WL[127]}
C {devices/lab_pin.sym} 360.0 -1290.0 0 0 {name=l133 lab=WL[126]}
C {devices/lab_pin.sym} 360.0 -1270.0 0 0 {name=l134 lab=WL[125]}
C {devices/lab_pin.sym} 360.0 -1250.0 0 0 {name=l135 lab=WL[124]}
C {devices/lab_pin.sym} 360.0 -1230.0 0 0 {name=l136 lab=WL[123]}
C {devices/lab_pin.sym} 360.0 -1210.0 0 0 {name=l137 lab=WL[122]}
C {devices/lab_pin.sym} 360.0 -1190.0 0 0 {name=l138 lab=WL[121]}
C {devices/lab_pin.sym} 360.0 -1170.0 0 0 {name=l139 lab=WL[120]}
C {devices/lab_pin.sym} 360.0 -1150.0 0 0 {name=l140 lab=WL[119]}
C {devices/lab_pin.sym} 360.0 -1130.0 0 0 {name=l141 lab=WL[118]}
C {devices/lab_pin.sym} 360.0 -1110.0 0 0 {name=l142 lab=WL[117]}
C {devices/lab_pin.sym} 360.0 -1090.0 0 0 {name=l143 lab=WL[116]}
C {devices/lab_pin.sym} 360.0 -1070.0 0 0 {name=l144 lab=WL[115]}
C {devices/lab_pin.sym} 360.0 -1050.0 0 0 {name=l145 lab=WL[114]}
C {devices/lab_pin.sym} 360.0 -1030.0 0 0 {name=l146 lab=WL[113]}
C {devices/lab_pin.sym} 360.0 -1010.0 0 0 {name=l147 lab=WL[112]}
C {devices/lab_pin.sym} 360.0 -990.0 0 0 {name=l148 lab=WL[111]}
C {devices/lab_pin.sym} 360.0 -970.0 0 0 {name=l149 lab=WL[110]}
C {devices/lab_pin.sym} 360.0 -950.0 0 0 {name=l150 lab=WL[109]}
C {devices/lab_pin.sym} 360.0 -930.0 0 0 {name=l151 lab=WL[108]}
C {devices/lab_pin.sym} 360.0 -910.0 0 0 {name=l152 lab=WL[107]}
C {devices/lab_pin.sym} 360.0 -890.0 0 0 {name=l153 lab=WL[106]}
C {devices/lab_pin.sym} 360.0 -870.0 0 0 {name=l154 lab=WL[105]}
C {devices/lab_pin.sym} 360.0 -850.0 0 0 {name=l155 lab=WL[104]}
C {devices/lab_pin.sym} 360.0 -830.0 0 0 {name=l156 lab=WL[103]}
C {devices/lab_pin.sym} 360.0 -810.0 0 0 {name=l157 lab=WL[102]}
C {devices/lab_pin.sym} 360.0 -790.0 0 0 {name=l158 lab=WL[101]}
C {devices/lab_pin.sym} 360.0 -770.0 0 0 {name=l159 lab=WL[100]}
C {devices/lab_pin.sym} 360.0 -750.0 0 0 {name=l160 lab=WL[99]}
C {devices/lab_pin.sym} 360.0 -730.0 0 0 {name=l161 lab=WL[98]}
C {devices/lab_pin.sym} 360.0 -710.0 0 0 {name=l162 lab=WL[97]}
C {devices/lab_pin.sym} 360.0 -690.0 0 0 {name=l163 lab=WL[96]}
C {devices/lab_pin.sym} 360.0 -670.0 0 0 {name=l164 lab=WL[95]}
C {devices/lab_pin.sym} 360.0 -650.0 0 0 {name=l165 lab=WL[94]}
C {devices/lab_pin.sym} 360.0 -630.0 0 0 {name=l166 lab=WL[93]}
C {devices/lab_pin.sym} 360.0 -610.0 0 0 {name=l167 lab=WL[92]}
C {devices/lab_pin.sym} 360.0 -590.0 0 0 {name=l168 lab=WL[91]}
C {devices/lab_pin.sym} 360.0 -570.0 0 0 {name=l169 lab=WL[90]}
C {devices/lab_pin.sym} 360.0 -550.0 0 0 {name=l170 lab=WL[89]}
C {devices/lab_pin.sym} 360.0 -530.0 0 0 {name=l171 lab=WL[88]}
C {devices/lab_pin.sym} 360.0 -510.0 0 0 {name=l172 lab=WL[87]}
C {devices/lab_pin.sym} 360.0 -490.0 0 0 {name=l173 lab=WL[86]}
C {devices/lab_pin.sym} 360.0 -470.0 0 0 {name=l174 lab=WL[85]}
C {devices/lab_pin.sym} 360.0 -450.0 0 0 {name=l175 lab=WL[84]}
C {devices/lab_pin.sym} 360.0 -430.0 0 0 {name=l176 lab=WL[83]}
C {devices/lab_pin.sym} 360.0 -410.0 0 0 {name=l177 lab=WL[82]}
C {devices/lab_pin.sym} 360.0 -390.0 0 0 {name=l178 lab=WL[81]}
C {devices/lab_pin.sym} 360.0 -370.0 0 0 {name=l179 lab=WL[80]}
C {devices/lab_pin.sym} 360.0 -350.0 0 0 {name=l180 lab=WL[79]}
C {devices/lab_pin.sym} 360.0 -330.0 0 0 {name=l181 lab=WL[78]}
C {devices/lab_pin.sym} 360.0 -310.0 0 0 {name=l182 lab=WL[77]}
C {devices/lab_pin.sym} 360.0 -290.0 0 0 {name=l183 lab=WL[76]}
C {devices/lab_pin.sym} 360.0 -270.0 0 0 {name=l184 lab=WL[75]}
C {devices/lab_pin.sym} 360.0 -250.0 0 0 {name=l185 lab=WL[74]}
C {devices/lab_pin.sym} 360.0 -230.0 0 0 {name=l186 lab=WL[73]}
C {devices/lab_pin.sym} 360.0 -210.0 0 0 {name=l187 lab=WL[72]}
C {devices/lab_pin.sym} 360.0 -190.0 0 0 {name=l188 lab=WL[71]}
C {devices/lab_pin.sym} 360.0 -170.0 0 0 {name=l189 lab=WL[70]}
C {devices/lab_pin.sym} 360.0 -150.0 0 0 {name=l190 lab=WL[69]}
C {devices/lab_pin.sym} 360.0 -130.0 0 0 {name=l191 lab=WL[68]}
C {devices/lab_pin.sym} 360.0 -110.0 0 0 {name=l192 lab=WL[67]}
C {devices/lab_pin.sym} 360.0 -90.0 0 0 {name=l193 lab=WL[66]}
C {devices/lab_pin.sym} 360.0 -70.0 0 0 {name=l194 lab=WL[65]}
C {devices/lab_pin.sym} 360.0 -50.0 0 0 {name=l195 lab=WL[64]}
C {devices/lab_pin.sym} 360.0 -30.0 0 0 {name=l196 lab=WL[63]}
C {devices/lab_pin.sym} 360.0 -10.0 0 0 {name=l197 lab=WL[62]}
C {devices/lab_pin.sym} 360.0 10.0 0 0 {name=l198 lab=WL[61]}
C {devices/lab_pin.sym} 360.0 30.0 0 0 {name=l199 lab=WL[60]}
C {devices/lab_pin.sym} 360.0 50.0 0 0 {name=l200 lab=WL[59]}
C {devices/lab_pin.sym} 360.0 70.0 0 0 {name=l201 lab=WL[58]}
C {devices/lab_pin.sym} 360.0 90.0 0 0 {name=l202 lab=WL[57]}
C {devices/lab_pin.sym} 360.0 110.0 0 0 {name=l203 lab=WL[56]}
C {devices/lab_pin.sym} 360.0 130.0 0 0 {name=l204 lab=WL[55]}
C {devices/lab_pin.sym} 360.0 150.0 0 0 {name=l205 lab=WL[54]}
C {devices/lab_pin.sym} 360.0 170.0 0 0 {name=l206 lab=WL[53]}
C {devices/lab_pin.sym} 360.0 190.0 0 0 {name=l207 lab=WL[52]}
C {devices/lab_pin.sym} 360.0 210.0 0 0 {name=l208 lab=WL[51]}
C {devices/lab_pin.sym} 360.0 230.0 0 0 {name=l209 lab=WL[50]}
C {devices/lab_pin.sym} 360.0 250.0 0 0 {name=l210 lab=WL[49]}
C {devices/lab_pin.sym} 360.0 270.0 0 0 {name=l211 lab=WL[48]}
C {devices/lab_pin.sym} 360.0 290.0 0 0 {name=l212 lab=WL[47]}
C {devices/lab_pin.sym} 360.0 310.0 0 0 {name=l213 lab=WL[46]}
C {devices/lab_pin.sym} 360.0 330.0 0 0 {name=l214 lab=WL[45]}
C {devices/lab_pin.sym} 360.0 350.0 0 0 {name=l215 lab=WL[44]}
C {devices/lab_pin.sym} 360.0 370.0 0 0 {name=l216 lab=WL[43]}
C {devices/lab_pin.sym} 360.0 390.0 0 0 {name=l217 lab=WL[42]}
C {devices/lab_pin.sym} 360.0 410.0 0 0 {name=l218 lab=WL[41]}
C {devices/lab_pin.sym} 360.0 430.0 0 0 {name=l219 lab=WL[40]}
C {devices/lab_pin.sym} 360.0 450.0 0 0 {name=l220 lab=WL[39]}
C {devices/lab_pin.sym} 360.0 470.0 0 0 {name=l221 lab=WL[38]}
C {devices/lab_pin.sym} 360.0 490.0 0 0 {name=l222 lab=WL[37]}
C {devices/lab_pin.sym} 360.0 510.0 0 0 {name=l223 lab=WL[36]}
C {devices/lab_pin.sym} 360.0 530.0 0 0 {name=l224 lab=WL[35]}
C {devices/lab_pin.sym} 360.0 550.0 0 0 {name=l225 lab=WL[34]}
C {devices/lab_pin.sym} 360.0 570.0 0 0 {name=l226 lab=WL[33]}
C {devices/lab_pin.sym} 360.0 590.0 0 0 {name=l227 lab=WL[32]}
C {devices/lab_pin.sym} 360.0 610.0 0 0 {name=l228 lab=WL[31]}
C {devices/lab_pin.sym} 360.0 630.0 0 0 {name=l229 lab=WL[30]}
C {devices/lab_pin.sym} 360.0 650.0 0 0 {name=l230 lab=WL[29]}
C {devices/lab_pin.sym} 360.0 670.0 0 0 {name=l231 lab=WL[28]}
C {devices/lab_pin.sym} 360.0 690.0 0 0 {name=l232 lab=WL[27]}
C {devices/lab_pin.sym} 360.0 710.0 0 0 {name=l233 lab=WL[26]}
C {devices/lab_pin.sym} 360.0 730.0 0 0 {name=l234 lab=WL[25]}
C {devices/lab_pin.sym} 360.0 750.0 0 0 {name=l235 lab=WL[24]}
C {devices/lab_pin.sym} 360.0 770.0 0 0 {name=l236 lab=WL[23]}
C {devices/lab_pin.sym} 360.0 790.0 0 0 {name=l237 lab=WL[22]}
C {devices/lab_pin.sym} 360.0 810.0 0 0 {name=l238 lab=WL[21]}
C {devices/lab_pin.sym} 360.0 830.0 0 0 {name=l239 lab=WL[20]}
C {devices/lab_pin.sym} 360.0 850.0 0 0 {name=l240 lab=WL[19]}
C {devices/lab_pin.sym} 360.0 870.0 0 0 {name=l241 lab=WL[18]}
C {devices/lab_pin.sym} 360.0 890.0 0 0 {name=l242 lab=WL[17]}
C {devices/lab_pin.sym} 360.0 910.0 0 0 {name=l243 lab=WL[16]}
C {devices/lab_pin.sym} 360.0 930.0 0 0 {name=l244 lab=WL[15]}
C {devices/lab_pin.sym} 360.0 950.0 0 0 {name=l245 lab=WL[14]}
C {devices/lab_pin.sym} 360.0 970.0 0 0 {name=l246 lab=WL[13]}
C {devices/lab_pin.sym} 360.0 990.0 0 0 {name=l247 lab=WL[12]}
C {devices/lab_pin.sym} 360.0 1010.0 0 0 {name=l248 lab=WL[11]}
C {devices/lab_pin.sym} 360.0 1030.0 0 0 {name=l249 lab=WL[10]}
C {devices/lab_pin.sym} 360.0 1050.0 0 0 {name=l250 lab=WL[9]}
C {devices/lab_pin.sym} 360.0 1070.0 0 0 {name=l251 lab=WL[8]}
C {devices/lab_pin.sym} 360.0 1090.0 0 0 {name=l252 lab=WL[7]}
C {devices/lab_pin.sym} 360.0 1110.0 0 0 {name=l253 lab=WL[6]}
C {devices/lab_pin.sym} 360.0 1130.0 0 0 {name=l254 lab=WL[5]}
C {devices/lab_pin.sym} 360.0 1150.0 0 0 {name=l255 lab=WL[4]}
C {devices/lab_pin.sym} 360.0 1170.0 0 0 {name=l256 lab=WL[3]}
C {devices/lab_pin.sym} 360.0 1190.0 0 0 {name=l257 lab=WL[2]}
C {devices/lab_pin.sym} 360.0 1210.0 0 0 {name=l258 lab=WL[1]}
C {devices/lab_pin.sym} 360.0 1230.0 0 0 {name=l259 lab=WL[0]}
C {devices/lab_pin.sym} 360.0 1250.0 0 0 {name=l260 lab=BL1}
C {devices/lab_pin.sym} 360.0 1270.0 0 0 {name=l261 lab=BLB1}
C {devices/lab_pin.sym} 360.0 1290.0 0 0 {name=l262 lab=VDD}
C {devices/lab_pin.sym} 360.0 1310.0 0 0 {name=l263 lab=VSS}
C {column/precharge.sym} 800 0 0 0 {name=XPC0}
C {devices/lab_pin.sym} 760.0 -40.0 0 0 {name=l264 lab=PRE_B}
C {devices/lab_pin.sym} 760.0 -20.0 0 0 {name=l265 lab=BL0}
C {devices/lab_pin.sym} 760.0 0.0 0 0 {name=l266 lab=BLB0}
C {devices/lab_pin.sym} 760.0 20.0 0 0 {name=l267 lab=VDD}
C {devices/lab_pin.sym} 760.0 40.0 0 0 {name=l268 lab=VSS}
C {column/precharge.sym} 1200 0 0 0 {name=XPC1}
C {devices/lab_pin.sym} 1160.0 -40.0 0 0 {name=l269 lab=PRE_B}
C {devices/lab_pin.sym} 1160.0 -20.0 0 0 {name=l270 lab=BL1}
C {devices/lab_pin.sym} 1160.0 0.0 0 0 {name=l271 lab=BLB1}
C {devices/lab_pin.sym} 1160.0 20.0 0 0 {name=l272 lab=VDD}
C {devices/lab_pin.sym} 1160.0 40.0 0 0 {name=l273 lab=VSS}
C {column/column_mux.sym} 0 2760 0 0 {name=XMX}
C {devices/lab_pin.sym} -40.0 2650.0 0 0 {name=l274 lab=SEL0}
C {devices/lab_pin.sym} -40.0 2670.0 0 0 {name=l275 lab=SEL0B}
C {devices/lab_pin.sym} -40.0 2690.0 0 0 {name=l276 lab=SEL1}
C {devices/lab_pin.sym} -40.0 2710.0 0 0 {name=l277 lab=SEL1B}
C {devices/lab_pin.sym} -40.0 2730.0 0 0 {name=l278 lab=BL0}
C {devices/lab_pin.sym} -40.0 2750.0 0 0 {name=l279 lab=BLB0}
C {devices/lab_pin.sym} -40.0 2770.0 0 0 {name=l280 lab=BL1}
C {devices/lab_pin.sym} -40.0 2790.0 0 0 {name=l281 lab=BLB1}
C {devices/lab_pin.sym} -40.0 2810.0 0 0 {name=l282 lab=BLM}
C {devices/lab_pin.sym} -40.0 2830.0 0 0 {name=l283 lab=BLBM}
C {devices/lab_pin.sym} -40.0 2850.0 0 0 {name=l284 lab=VDD}
C {devices/lab_pin.sym} -40.0 2870.0 0 0 {name=l285 lab=VSS}
C {column/sense_amp.sym} 400 2760 0 0 {name=XSA}
C {devices/lab_pin.sym} 360.0 2700.0 0 0 {name=l286 lab=SAE}
C {devices/lab_pin.sym} 360.0 2720.0 0 0 {name=l287 lab=BLM}
C {devices/lab_pin.sym} 360.0 2740.0 0 0 {name=l288 lab=BLBM}
C {devices/lab_pin.sym} 360.0 2760.0 0 0 {name=l289 lab=DOUT}
C {devices/lab_pin.sym} 360.0 2780.0 0 0 {name=l290 lab=DOUTB}
C {devices/lab_pin.sym} 360.0 2800.0 0 0 {name=l291 lab=VDD}
C {devices/lab_pin.sym} 360.0 2820.0 0 0 {name=l292 lab=VSS}
C {column/write_driver.sym} 800 2760 0 0 {name=XWR}
C {devices/lab_pin.sym} 760 2710 0 0 {name=lw183 lab=WEI}
C {devices/lab_pin.sym} 760 2730 0 0 {name=lw184 lab=DIN}
C {devices/lab_pin.sym} 760 2750 0 0 {name=lw185 lab=BLM}
C {devices/lab_pin.sym} 760 2770 0 0 {name=lw186 lab=BLBM}
C {devices/lab_pin.sym} 760 2790 0 0 {name=lw187 lab=VDD}
C {devices/lab_pin.sym} 760 2810 0 0 {name=lw188 lab=VSS}
C {devices/ipin.sym} -900 -300 0 0 {name=pw189 lab=PRE_B}
C {devices/ipin.sym} -900 -260 0 0 {name=pw190 lab=SEL0}
C {devices/ipin.sym} -900 -220 0 0 {name=pw191 lab=SEL0B}
C {devices/ipin.sym} -900 -180 0 0 {name=pw192 lab=SEL1}
C {devices/ipin.sym} -900 -140 0 0 {name=pw193 lab=SEL1B}
C {devices/ipin.sym} -900 -100 0 0 {name=pw194 lab=SAE}
C {devices/ipin.sym} -900 -60 0 0 {name=pw195 lab=WE}
C {devices/ipin.sym} -900 -20 0 0 {name=pw196 lab=DIN}
C {devices/ipin.sym} -900 20 0 0 {name=pw197 lab=WEN}
C {devices/ipin.sym} -900 60 0 0 {name=pw198 lab=WL[127]}
C {devices/ipin.sym} -900 100 0 0 {name=pw199 lab=WL[126]}
C {devices/ipin.sym} -900 140 0 0 {name=pw200 lab=WL[125]}
C {devices/ipin.sym} -900 180 0 0 {name=pw201 lab=WL[124]}
C {devices/ipin.sym} -900 220 0 0 {name=pw202 lab=WL[123]}
C {devices/ipin.sym} -900 260 0 0 {name=pw203 lab=WL[122]}
C {devices/ipin.sym} -900 300 0 0 {name=pw204 lab=WL[121]}
C {devices/ipin.sym} -900 340 0 0 {name=pw205 lab=WL[120]}
C {devices/ipin.sym} -900 380 0 0 {name=pw206 lab=WL[119]}
C {devices/ipin.sym} -900 420 0 0 {name=pw207 lab=WL[118]}
C {devices/ipin.sym} -900 460 0 0 {name=pw208 lab=WL[117]}
C {devices/ipin.sym} -900 500 0 0 {name=pw209 lab=WL[116]}
C {devices/ipin.sym} -900 540 0 0 {name=pw210 lab=WL[115]}
C {devices/ipin.sym} -900 580 0 0 {name=pw211 lab=WL[114]}
C {devices/ipin.sym} -900 620 0 0 {name=pw212 lab=WL[113]}
C {devices/ipin.sym} -900 660 0 0 {name=pw213 lab=WL[112]}
C {devices/ipin.sym} -900 700 0 0 {name=pw214 lab=WL[111]}
C {devices/ipin.sym} -900 740 0 0 {name=pw215 lab=WL[110]}
C {devices/ipin.sym} -900 780 0 0 {name=pw216 lab=WL[109]}
C {devices/ipin.sym} -900 820 0 0 {name=pw217 lab=WL[108]}
C {devices/ipin.sym} -900 860 0 0 {name=pw218 lab=WL[107]}
C {devices/ipin.sym} -900 900 0 0 {name=pw219 lab=WL[106]}
C {devices/ipin.sym} -900 940 0 0 {name=pw220 lab=WL[105]}
C {devices/ipin.sym} -900 980 0 0 {name=pw221 lab=WL[104]}
C {devices/ipin.sym} -900 1020 0 0 {name=pw222 lab=WL[103]}
C {devices/ipin.sym} -900 1060 0 0 {name=pw223 lab=WL[102]}
C {devices/ipin.sym} -900 1100 0 0 {name=pw224 lab=WL[101]}
C {devices/ipin.sym} -900 1140 0 0 {name=pw225 lab=WL[100]}
C {devices/ipin.sym} -900 1180 0 0 {name=pw226 lab=WL[99]}
C {devices/ipin.sym} -900 1220 0 0 {name=pw227 lab=WL[98]}
C {devices/ipin.sym} -900 1260 0 0 {name=pw228 lab=WL[97]}
C {devices/ipin.sym} -900 1300 0 0 {name=pw229 lab=WL[96]}
C {devices/ipin.sym} -900 1340 0 0 {name=pw230 lab=WL[95]}
C {devices/ipin.sym} -900 1380 0 0 {name=pw231 lab=WL[94]}
C {devices/ipin.sym} -900 1420 0 0 {name=pw232 lab=WL[93]}
C {devices/ipin.sym} -900 1460 0 0 {name=pw233 lab=WL[92]}
C {devices/ipin.sym} -900 1500 0 0 {name=pw234 lab=WL[91]}
C {devices/ipin.sym} -900 1540 0 0 {name=pw235 lab=WL[90]}
C {devices/ipin.sym} -900 1580 0 0 {name=pw236 lab=WL[89]}
C {devices/ipin.sym} -900 1620 0 0 {name=pw237 lab=WL[88]}
C {devices/ipin.sym} -900 1660 0 0 {name=pw238 lab=WL[87]}
C {devices/ipin.sym} -900 1700 0 0 {name=pw239 lab=WL[86]}
C {devices/ipin.sym} -900 1740 0 0 {name=pw240 lab=WL[85]}
C {devices/ipin.sym} -900 1780 0 0 {name=pw241 lab=WL[84]}
C {devices/ipin.sym} -900 1820 0 0 {name=pw242 lab=WL[83]}
C {devices/ipin.sym} -900 1860 0 0 {name=pw243 lab=WL[82]}
C {devices/ipin.sym} -900 1900 0 0 {name=pw244 lab=WL[81]}
C {devices/ipin.sym} -900 1940 0 0 {name=pw245 lab=WL[80]}
C {devices/ipin.sym} -900 1980 0 0 {name=pw246 lab=WL[79]}
C {devices/ipin.sym} -900 2020 0 0 {name=pw247 lab=WL[78]}
C {devices/ipin.sym} -900 2060 0 0 {name=pw248 lab=WL[77]}
C {devices/ipin.sym} -900 2100 0 0 {name=pw249 lab=WL[76]}
C {devices/ipin.sym} -900 2140 0 0 {name=pw250 lab=WL[75]}
C {devices/ipin.sym} -900 2180 0 0 {name=pw251 lab=WL[74]}
C {devices/ipin.sym} -900 2220 0 0 {name=pw252 lab=WL[73]}
C {devices/ipin.sym} -900 2260 0 0 {name=pw253 lab=WL[72]}
C {devices/ipin.sym} -900 2300 0 0 {name=pw254 lab=WL[71]}
C {devices/ipin.sym} -900 2340 0 0 {name=pw255 lab=WL[70]}
C {devices/ipin.sym} -900 2380 0 0 {name=pw256 lab=WL[69]}
C {devices/ipin.sym} -900 2420 0 0 {name=pw257 lab=WL[68]}
C {devices/ipin.sym} -900 2460 0 0 {name=pw258 lab=WL[67]}
C {devices/ipin.sym} -900 2500 0 0 {name=pw259 lab=WL[66]}
C {devices/ipin.sym} -900 2540 0 0 {name=pw260 lab=WL[65]}
C {devices/ipin.sym} -900 2580 0 0 {name=pw261 lab=WL[64]}
C {devices/ipin.sym} -900 2620 0 0 {name=pw262 lab=WL[63]}
C {devices/ipin.sym} -900 2660 0 0 {name=pw263 lab=WL[62]}
C {devices/ipin.sym} -900 2700 0 0 {name=pw264 lab=WL[61]}
C {devices/ipin.sym} -900 2740 0 0 {name=pw265 lab=WL[60]}
C {devices/ipin.sym} -900 2780 0 0 {name=pw266 lab=WL[59]}
C {devices/ipin.sym} -900 2820 0 0 {name=pw267 lab=WL[58]}
C {devices/ipin.sym} -900 2860 0 0 {name=pw268 lab=WL[57]}
C {devices/ipin.sym} -900 2900 0 0 {name=pw269 lab=WL[56]}
C {devices/ipin.sym} -900 2940 0 0 {name=pw270 lab=WL[55]}
C {devices/ipin.sym} -900 2980 0 0 {name=pw271 lab=WL[54]}
C {devices/ipin.sym} -900 3020 0 0 {name=pw272 lab=WL[53]}
C {devices/ipin.sym} -900 3060 0 0 {name=pw273 lab=WL[52]}
C {devices/ipin.sym} -900 3100 0 0 {name=pw274 lab=WL[51]}
C {devices/ipin.sym} -900 3140 0 0 {name=pw275 lab=WL[50]}
C {devices/ipin.sym} -900 3180 0 0 {name=pw276 lab=WL[49]}
C {devices/ipin.sym} -900 3220 0 0 {name=pw277 lab=WL[48]}
C {devices/ipin.sym} -900 3260 0 0 {name=pw278 lab=WL[47]}
C {devices/ipin.sym} -900 3300 0 0 {name=pw279 lab=WL[46]}
C {devices/ipin.sym} -900 3340 0 0 {name=pw280 lab=WL[45]}
C {devices/ipin.sym} -900 3380 0 0 {name=pw281 lab=WL[44]}
C {devices/ipin.sym} -900 3420 0 0 {name=pw282 lab=WL[43]}
C {devices/ipin.sym} -900 3460 0 0 {name=pw283 lab=WL[42]}
C {devices/ipin.sym} -900 3500 0 0 {name=pw284 lab=WL[41]}
C {devices/ipin.sym} -900 3540 0 0 {name=pw285 lab=WL[40]}
C {devices/ipin.sym} -900 3580 0 0 {name=pw286 lab=WL[39]}
C {devices/ipin.sym} -900 3620 0 0 {name=pw287 lab=WL[38]}
C {devices/ipin.sym} -900 3660 0 0 {name=pw288 lab=WL[37]}
C {devices/ipin.sym} -900 3700 0 0 {name=pw289 lab=WL[36]}
C {devices/ipin.sym} -900 3740 0 0 {name=pw290 lab=WL[35]}
C {devices/ipin.sym} -900 3780 0 0 {name=pw291 lab=WL[34]}
C {devices/ipin.sym} -900 3820 0 0 {name=pw292 lab=WL[33]}
C {devices/ipin.sym} -900 3860 0 0 {name=pw293 lab=WL[32]}
C {devices/ipin.sym} -900 3900 0 0 {name=pw294 lab=WL[31]}
C {devices/ipin.sym} -900 3940 0 0 {name=pw295 lab=WL[30]}
C {devices/ipin.sym} -900 3980 0 0 {name=pw296 lab=WL[29]}
C {devices/ipin.sym} -900 4020 0 0 {name=pw297 lab=WL[28]}
C {devices/ipin.sym} -900 4060 0 0 {name=pw298 lab=WL[27]}
C {devices/ipin.sym} -900 4100 0 0 {name=pw299 lab=WL[26]}
C {devices/ipin.sym} -900 4140 0 0 {name=pw300 lab=WL[25]}
C {devices/ipin.sym} -900 4180 0 0 {name=pw301 lab=WL[24]}
C {devices/ipin.sym} -900 4220 0 0 {name=pw302 lab=WL[23]}
C {devices/ipin.sym} -900 4260 0 0 {name=pw303 lab=WL[22]}
C {devices/ipin.sym} -900 4300 0 0 {name=pw304 lab=WL[21]}
C {devices/ipin.sym} -900 4340 0 0 {name=pw305 lab=WL[20]}
C {devices/ipin.sym} -900 4380 0 0 {name=pw306 lab=WL[19]}
C {devices/ipin.sym} -900 4420 0 0 {name=pw307 lab=WL[18]}
C {devices/ipin.sym} -900 4460 0 0 {name=pw308 lab=WL[17]}
C {devices/ipin.sym} -900 4500 0 0 {name=pw309 lab=WL[16]}
C {devices/ipin.sym} -900 4540 0 0 {name=pw310 lab=WL[15]}
C {devices/ipin.sym} -900 4580 0 0 {name=pw311 lab=WL[14]}
C {devices/ipin.sym} -900 4620 0 0 {name=pw312 lab=WL[13]}
C {devices/ipin.sym} -900 4660 0 0 {name=pw313 lab=WL[12]}
C {devices/ipin.sym} -900 4700 0 0 {name=pw314 lab=WL[11]}
C {devices/ipin.sym} -900 4740 0 0 {name=pw315 lab=WL[10]}
C {devices/ipin.sym} -900 4780 0 0 {name=pw316 lab=WL[9]}
C {devices/ipin.sym} -900 4820 0 0 {name=pw317 lab=WL[8]}
C {devices/ipin.sym} -900 4860 0 0 {name=pw318 lab=WL[7]}
C {devices/ipin.sym} -900 4900 0 0 {name=pw319 lab=WL[6]}
C {devices/ipin.sym} -900 4940 0 0 {name=pw320 lab=WL[5]}
C {devices/ipin.sym} -900 4980 0 0 {name=pw321 lab=WL[4]}
C {devices/ipin.sym} -900 5020 0 0 {name=pw322 lab=WL[3]}
C {devices/ipin.sym} -900 5060 0 0 {name=pw323 lab=WL[2]}
C {devices/ipin.sym} -900 5100 0 0 {name=pw324 lab=WL[1]}
C {devices/ipin.sym} -900 5140 0 0 {name=pw325 lab=WL[0]}
C {devices/iopin.sym} -900 5180 0 0 {name=pw326 lab=DOUT}
C {devices/iopin.sym} -900 5220 0 0 {name=pw327 lab=DOUTB}
C {devices/iopin.sym} -900 5260 0 0 {name=pw328 lab=VDD}
C {devices/iopin.sym} -900 5300 0 0 {name=pw329 lab=VSS}
C {gates/inv.sym} 1200 2760 0 0 {name=XWI}
C {devices/lab_pin.sym} 1160 2730 0 0 {name=lw330 lab=WE}
C {devices/lab_pin.sym} 1160 2750 0 0 {name=lw331 lab=WEB}
C {devices/lab_pin.sym} 1160 2770 0 0 {name=lw332 lab=VDD}
C {devices/lab_pin.sym} 1160 2790 0 0 {name=lw333 lab=VSS}
C {gates/nor2.sym} 1600 2760 0 0 {name=XWG}
C {devices/lab_pin.sym} 1560 2720 0 0 {name=lw334 lab=WEB}
C {devices/lab_pin.sym} 1560 2740 0 0 {name=lw335 lab=WEN}
C {devices/lab_pin.sym} 1560 2760 0 0 {name=lw336 lab=WEI}
C {devices/lab_pin.sym} 1560 2780 0 0 {name=lw337 lab=VDD}
C {devices/lab_pin.sym} 1560 2800 0 0 {name=lw338 lab=VSS}
C {devices/code_shown.sym} -900 0 0 0 {name=NOTE only_toplevel=false
place=header
value="* one I/O bit: two bit-line pairs (mux 2), precharge on each, column mux, sense amp, write driver; both precharges share PRE_B"}
